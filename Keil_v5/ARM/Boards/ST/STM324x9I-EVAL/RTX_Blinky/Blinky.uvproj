# Keil uVision project Blinky.uvproj, settings and files
target STM32F439 RAM (ARM-ADS)
  device: STM32F439NI STMicroelectronics
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: Blinky
  c flags: Optim=1
  c define: VECT_TAB_SRAM
  library: MicroLIB
  memory RVCT4: ROM 0x20000000 size 0x10000
  memory RVCT9: RAM 0x20010000 size 0x10000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group StartUp
    ./: system_stm32f4xx.c startup_stm32f429_439xx.s
  group RTX Configuation
    ./: RTX_Conf_CM.c
  group Source Files
    ./: Blinky.c LED.c
  group Documentation
    ./: Abstract.txt
target STM32F439 Flash (ARM-ADS)
  device: STM32F439NI STMicroelectronics
  cpu: as above
  output: Blinky
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
