# Keil uVision project GUIDemo.uvproj, settings and files
target MCBSTM32F400 (ARM-ADS)
  device: STM32F407IG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: GUIDemo
  c flags: Optim=4 v6Lang=1 v6LangP=1
  c define: DATA_IN_ExtSRAM JOYSTICK_ROTATE GUI_BYTESPERPIXEL=4 SHOW_GUIDEMO_AUTOMOTIVE SHOW_GUIDEMO_BARGRAPH SHOW_GUIDEMO_BITMAP SHOW_GUIDEMO_COLORBAR SHOW_GUIDEMO_CURSOR  SHOW_GUIDEMO_GRAPH SHOW_GUIDEMO_ICONVIEW SHOW_GUIDEMO_LISTVIEW SHOW_GUIDEMO_SPEED SHOW_GUIDEMO_TRANSPARENTDIALOG SHOW_GUIDEMO_TREEVIEW SHOW_GUIDEMO_WASHINGMACHINE
  c include: C:\Keil\ARM\Segger\emWin\Include
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT6: RAM 0x68000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Startup
    ./: startup_stm32f40_41xxx.s system_stm32f4xx.c
  group Drivers
    ./: LCDConf.c LCD_X_16BitIF_STM32F4xx.c I2C_STM32F4xx.c TSC_STMPE811.c JOY.c
  group GUI Library
    ./: GUIConf.c GUI_X.c
    C:/Keil/ARM/Segger/emWin/Lib/: GUI_CM3.lib
  group Source Code
    ./: main.c
    C:/Keil/ARM/Segger/emWin/Sample/Application/GUIDemo/: GUIDEMO.c GUIDEMO_Automotive.c GUIDEMO_BarGraph.c GUIDEMO_Bitmap.c GUIDEMO_ColorBar.c GUIDEMO_Conf.c GUIDEMO_Cursor.c GUIDEMO_Graph.c GUIDEMO_IconView.c GUIDEMO_Intro.c GUIDEMO_Listview.c GUIDEMO_Resource.c GUIDEMO_Speed.c GUIDEMO_Start.c GUIDEMO_TransparentDialog.c GUIDEMO_Treeview.c GUIDEMO_WashingMachine.c
  group Documentation
    ./: Abstract.txt
target MCBSTM32F400 LCD_LG (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F407IG STMicroelectronics
  cpu: as above
  output: GUIDemo
  c flags: Optim=4 v6Lang=1 v6LangP=1
  c define: as above
  c include: C:\Keil\ARM\Segger\emWin\Include
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT6: RAM 0x68000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
