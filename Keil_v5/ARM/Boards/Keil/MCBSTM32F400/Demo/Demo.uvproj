# Keil uVision project Demo.uvproj, settings and files
target STM32F407 MDK-Lite (ARM-ADS)
  device: STM32F407IG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: Demo
  c flags: Optim=1
  c define: _EVAL_VERSION_
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group StartUp
    ./: startup_stm32f40_41xxx.s system_stm32f4xx.c
  group Graphics
    ./: Arrows_16bpp_red.c Button_16bpp.c Bulb_16bpp.c
  group Drivers
    ./: LED.c I2C_STM32F4xx.c GLCD_16bitIF_STM32F4xx.c KBD.c JOY.c ADC.c CAM.c Accel_LIS3DH.c Gyro_L3G4200D.c TSC_STMPE811.c
  group Source Files
    ./: Demo.c
  group Documentation
    ./: Abstract.txt
target STM32F407 Flash (ARM-ADS)
  device: STM32F407IG STMicroelectronics
  cpu: as above
  output: Demo
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
