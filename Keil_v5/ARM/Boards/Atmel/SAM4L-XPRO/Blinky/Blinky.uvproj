# Keil uVision project Blinky.uvproj, settings and files
target SAM4L RAM (ARM-ADS)
  device: SAM4LC4C Atmel
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x0-0x3FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4")
  output: Blinky
  c flags: Optim=1
  c define: __USART
  library: MicroLIB
  memory RVCT4: ROM 0x20000000 size 0x4000
  memory RVCT9: RAM 0x20004000 size 0x4000
  group StartUp
    ./: startup_SAM4L.s system_sam4l.c
  group Source Files
    ./: Retarget.c Serial.c LED.c BTN.c Blinky.c
  group Documentation
    ./: Abstract.txt
target SAM4L Flash (ARM-ADS)
  device: SAM4LC4C Atmel
  cpu: as above
  output: Blinky
  c flags: Optim=1
  c define: __USART
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
