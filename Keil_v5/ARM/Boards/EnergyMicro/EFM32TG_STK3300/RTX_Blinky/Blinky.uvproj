# Keil uVision project Blinky.uvproj, settings and files
target EFM32TG840F32 Flash (ARM-ADS)
  device: EFM32TG840F32 Energy Micro
  cpu: IRAM(0x20000000-0x20000FFF) IROM(0-0x7FFF) CLOCK(32000000) CPUTYPE("Cortex-M3")
  output: Blinky
  c flags: Optim=1
  c define: DEBUG_EFM
  c misc: --c99
  c include: ..\bsp;..\..\..\..\RV31\LIB\EnergyMicro\emlib\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group StartUp
    ./: startup_efm32tg.s system_efm32tg.c
  group BSP
    ../bsp/: stk.c trace.c
  group EMLib
    ../../../../RV31/LIB/EnergyMicro/emlib/src/: em_acmp.c em_adc.c em_aes.c em_assert.c em_burtc.c em_cmu.c em_dac.c em_dbg.c em_dma.c em_ebi.c em_emu.c em_gpio.c em_i2c.c em_int.c em_lcd.c em_lesense.c em_letimer.c em_leuart.c em_mpu.c em_msc.c em_opamp.c em_pcnt.c em_prs.c em_rmu.c em_rtc.c em_system.c em_timer.c em_usart.c em_vcmp.c em_wdog.c
  group RTX Configuration
    ./: RTX_Conf_CM.c
  group Source Files
    ./: LED.c Blinky.c
  group Documentation
    ./: Abstract.txt
