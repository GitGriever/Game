# Keil uVision project CAN_Ex1.uvproj, settings and files
target STM32 Flash (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: CAN_Ex1
  c flags: Optim=1
  c include: .\
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group StartUp
    ./: startup_stm32f10x_cl.s system_stm32f10x_cl.c
  group Configuration
    ./: RTX_Conf_CM.c
  group CAN Core
    ./: CAN_Cfg.h
    C:/Keil/ARM/RL/CAN/SRC/: RTX_CAN.c
  group CAN Driver
    ./: CAN_STM32F107.c
  group Source
    ./: CAN_Ex1.c
  group Driver
    ./: GLCD_SPI_STM32.c
  group Documentation
    ./: Abstract.txt
