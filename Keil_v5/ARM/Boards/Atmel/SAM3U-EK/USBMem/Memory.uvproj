# Keil uVision project Memory.uvproj, settings and files
target SAM3U Flash (ARM-ADS)
  device: SAM3U4E Atmel
  cpu: IRAM(0x20000000-0x20007FFF) IRAM2(0x20080000-0x20083FFF) IROM(0x80000-0x9FFFF) IROM2(0x100000-0x11FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: Memory
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x80000 size 0x20000
  memory RVCT5: ROM 0x100000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x20080000 size 0x4000
  group StartUp
    ./: startup_SAM3U.s system_SAM3U.c
  group Disk Image
    ./: DiskImg.c
  group Source Files
    ./: usbcfg_SAM3U.h usbhw_SAM3U.c usbcore.c usbdesc.c usbuser.c mscuser.c memory.c
  group Documentation
    ./: Abstract.txt
