# Keil uVision project SMTP_demo.uvproj, settings and files
target XMC4500 (ARM-ADS)
  device: XMC4500-1024 Infineon
  cpu: IRAM(0x20000000-0x2000FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x0C000000-0x0C0FFFFF) IROM2(0x08000000-0x080FFFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") FPU2
  output: SMTP_demo
  c flags: Optim=4
  c include: ..\Library
  library: MicroLIB
  memory RVCT4: ROM 0xc000000 size 0x100000
  memory RVCT5: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source Files
    ./: SMTP_demo.c SMTP_uif.c
  group Configuration Files
    ./: Net_Config.c Net_Debug.c startup_XMC4500.s
  group Library
    ./../../../../../../../ARM/RV31/LIB/: TCP_CM3.lib TCPD_CM3.lib
    ../Library/: system_XMC4500.c ETH_XMC45xx.c ADC.c LED.c Serial.c
  group Documentation
    ./: Abstract.txt
target XMC4500 Debug (ARM-ADS)
  device: XMC4500-1024 Infineon
  cpu: as above
  output: SMTP_demo
  c flags: Optim=4
  c include: ..\Library
  library: MicroLIB
  memory RVCT4: ROM 0xc000000 size 0x100000
  memory RVCT5: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x10000000 size 0x10000
