# Keil uVision project Memory.uvproj, settings and files
target SAM3S Flash (ARM-ADS)
  device: SAM3S4C Atmel
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x400000-0x43FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: Memory
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x400000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group StartUp
    ./: startup_SAM3S.s system_SAM3S.c
  group Disk Image
    ./: DiskImg.c
  group Source Files
    ./: usbcfg.h usbcore.c usbdesc.c usbuser.c mscuser.c memory.c usbhw_SAM3S.c
  group Documentation
    ./: Abstract.txt
