# Keil uVision project MSD_File.uvproj, settings and files
target K53N512 (ARM-ADS)
  device: MK53N512CMD100 Freescale Semiconductor
  cpu: IRAM(0x1FFF0000-0x1FFFFFFF) IRAM2(0x20000000-0x2000FFFF) IROM(0x0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") ELITTLE
  output: MSD_File
  c flags: Optim=4
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x10000
  group Startup
    ./: startup_MK53N512ZCMD100.s system_MK53N512ZCMD100.c
  group Configuration
    ./: File_Config.c usb_config.c
  group Retarget
    ./: Retarget.c
  group Application
    ./: MSD_File.c Getline.c Serial.c fs_usbh_msc.c usbh_MK53.c
  group Library
    C:/Keil/ARM/RV31/LIB/: FS_CM3.lib USB_CM3.lib
  group Documentation
    ./: Abstract.txt
