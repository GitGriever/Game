# Keil uVision project MB9BFxxx.uvproj, settings and files
target MB9BF500_256 (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: MB9BF500_256
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=1
  c define: FLASH_MEM MB9BF500_256
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
  group Program Functions
    ./: FlashPrg.c
  group Device Description
    ./: FlashDev.c
target MB9xFxx1_64 (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: MB9BFx01_64
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=1
  c define: FLASH_MEM MB9BFx01_64
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target MB9xFxx2_128 (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: MB9BFx02_128
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=1
  c define: FLASH_MEM MB9BFx02_128
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target MB9xFxx4_256 (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: MB9BFx04_256
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=1
  c define: FLASH_MEM MB9BFx04_256
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target MB9xFxx5_384 (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: MB9BFx05_384
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=1
  c define: FLASH_MEM MB9BFx05_384
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target MB9xFxx6_512 (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: MB9BFx06_512
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=1
  c define: FLASH_MEM MB9BFx06_512
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target MB9xFxx7_768 (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: MB9BFx07_768
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=1
  c define: FLASH_MEM MB9BFx07_768
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target MB9xFxx8_1024 (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: MB9BFx08_1024
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=1
  c define: FLASH_MEM MB9BFx08_1024
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target MB9xFxxx_32WF (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: MB9xFxxx_32WF
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=1
  c define: FLASH_MEM MB9xFxxx_32WF
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
