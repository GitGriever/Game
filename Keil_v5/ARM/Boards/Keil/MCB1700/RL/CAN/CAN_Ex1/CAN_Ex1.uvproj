# Keil uVision project CAN_Ex1.uvproj, settings and files
target Simulator (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: CAN_Ex1
  c flags: Optim=4
  c include: .\
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Startup Code
    ./: startup_LPC17xx.s system_LPC17xx.c
  group Configuration
    ./: RTX_Conf_CM.c
  group CAN Core
    ./: CAN_Cfg.h
    C:/Keil/ARM/RL/CAN/SRC/: RTX_CAN.c
  group CAN Driver
    ./: CAN_LPC17xx.c
  group Source
    ./: CAN_Ex1.c ADC.c LED.c GLCD_SPI_LPC1700.c
  group Documentation
    ./: Abstract.txt
target LPC1768 Flash (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: as above
  output: CAN_Ex1
  c flags: Optim=4
  c include: .\
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
