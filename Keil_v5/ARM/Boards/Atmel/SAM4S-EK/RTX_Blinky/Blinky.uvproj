# Keil uVision project Blinky.uvproj, settings and files
target SAM4S RAM (ARM-ADS)
  device: SAM4S16C Atmel
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x400000-0x4FFFFF) CLOCK(12000000) CPUTYPE("Cortex-M4")
  output: Blinky
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x20000000 size 0x10000
  memory RVCT9: RAM 0x20010000 size 0x10000
  group StartUp Files
    ./: startup_SAM4S.s system_SAM4S.c
  group RTX Configuration
    ./: RTX_Conf_CM.c
  group Source Files
    ./: GLCD_8bitIF_SAM4S.c LED.c Blinky.c
  group Documentation
    ./: Abstract.txt
target SAM4S Flash (ARM-ADS)
  device: SAM4S16C Atmel
  cpu: as above
  output: Blinky
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x400000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
