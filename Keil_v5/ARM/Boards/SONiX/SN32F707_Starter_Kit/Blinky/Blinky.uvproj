# Keil uVision project Blinky.uvproj, settings and files
target SN32F707 Flash JLink (ARM-ADS)
  device: SN32F707 SONiX
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x0-0x7FFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: Blinky
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group StartUp
    ./: startup_SN32F700.s system_SN32F700.c
  group Source Files
    ./: Retarget.c Serial.c LED.c Blinky.c
  group Documentation
    ./: Abstract.txt
target SN32F707 Flash (ARM-ADS)
  device: SN32F707 SONiX
  cpu: as above
  output: Blinky
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2000
target SN32F707 RAM (ARM-ADS)
  device: SN32F707 SONiX
  cpu: as above
  output: Blinky
  c flags: Optim=1
  memory RVCT4: ROM 0x20000000 size 0x1000
  memory RVCT9: RAM 0x20001000 size 0x1000
