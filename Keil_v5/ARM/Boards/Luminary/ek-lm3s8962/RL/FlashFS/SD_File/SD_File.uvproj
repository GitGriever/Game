# Keil uVision project SD_File.uvproj, settings and files
target LM3S8962 (ARM-ADS)
  device: LM3S8962 Luminary Micro
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0-0x3FFFF) CLOCK(50000000) CPUTYPE("Cortex-M3")
  output: SD_File
  c flags: Optim=4
  c define: rvmdk PART_LM3S8962
  c include: C:/Keil/ARM/RV31/LIB/Luminary
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source Files
    ./: SD_File.c Serial.c Retarget.c Getline.c
  group Configuration Files
    ./: startup_rvmdk.S File_Config.c SPI_LM3S8962.c
  group Library
    C:/Keil/ARM/RV31/LIB/: FS_CM3.lib
    C:/Keil/ARM/RV31/LIB/Luminary/: driverlib-cm3.lib
  group Documentation
    ./: Abstract.txt
