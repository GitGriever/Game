# Keil uVision project Blinky.uvproj, settings and files
target XMC4400 PSRAM (ARM-ADS)
  device: XMC4400-512 Infineon
  cpu: IRAM(0x20000000-0x20007FFF) IRAM2(0x1FFFC000-0x1FFFFFFF) IROM(0x0C000000-0x0C07FFFF) IROM2(0x08000000-0x0807FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") FPU2
  output: Blinky
  c flags: Optim=1
  memory RVCT4: ROM 0x1fffc000 size 0x4000
  memory RVCT5: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group StartUp
    ./: startup_XMC4400.s system_XMC4400.c
  group Source Files
    ./: Retarget.c Serial.c LED.c Blinky.c
  group Documentation
    ./: Abstract.txt
target XMC4400 Flash (ARM-ADS)
  device: XMC4400-512 Infineon
  cpu: as above
  output: Blinky
  c flags: Optim=1
  memory RVCT4: ROM 0xc000000 size 0x80000
  memory RVCT5: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x1fffc000 size 0x4000
target XMC4400 cached Flash (ARM-ADS)
  device: XMC4400-512 Infineon
  cpu: as above
  output: Blinky
  c flags: Optim=1
  memory RVCT4: ROM 0xc000000 size 0x80000
  memory RVCT5: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x1fffc000 size 0x4000
