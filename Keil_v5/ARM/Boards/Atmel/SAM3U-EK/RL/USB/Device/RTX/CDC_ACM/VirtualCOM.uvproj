# Keil uVision project VirtualCOM.uvproj, settings and files
target SAM3U (ARM-ADS)
  device: SAM3U4E Atmel
  cpu: IRAM(0x20000000-0x20007FFF) IRAM2(0x20080000-0x20083FFF) IROM(0x80000-0x9FFFF) IROM2(0x100000-0x11FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: VirtualCOM
  c flags: Optim=4
  memory RVCT4: ROM 0x80000 size 0x20000
  memory RVCT5: ROM 0x100000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x20080000 size 0x4000
  group Startup Files
    ./: startup_SAM3U.s system_SAM3U.c SVC_Table.s
  group Configuration
    ./: RTX_Conf_CM.c usb_config.c
  group USB HW Driver
    ./: usbd_SAM3U.c
  group Source
    ./: USBD_Demo.c GLCD_16bitIF_SAM3U.c UART_SAM3U.c LED_SAM3U.c
    ./: usbd_user_cdc_acm.c
  group Library
    C:/Keil/ARM/RV31/LIB/: USB_CM3.lib
  group Documentation
    ./: Abstract.txt
