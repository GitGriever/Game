# Keil uVision project Blinky.uvproj, settings and files
target CMSIS-DAP -Flash (ARM-ADS)
  device: MKL02Z32xxx4 Freescale Semiconductor
  cpu: IRAM(0x1FFFFC00-0x1FFFFFFF) IRAM2(0x20000000-0x20000BFF) IROM(0x0-0x07FFF) CLOCK(8000000) CPUTYPE("Cortex-M0+") ELITTLE
  output: Blinky
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x1ffffc00 size 0x400
  memory RVCT10: RAM 0x20000000 size 0xc00
  group Startup
    ./: system_MKL02Z4.c startup_MKL02Z4.s
  group Source Files
    ./: Blinky.c
  group RTX Configuration
    ./: RTX_Config.c
  group Documentation
    ./: Abstract.txt
target ULink -Flash (ARM-ADS)
  device: MKL02Z32xxx4 Freescale Semiconductor
  cpu: as above
  output: Blinky
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x1ffffc00 size 0x400
  memory RVCT10: RAM 0x20000000 size 0xc00
