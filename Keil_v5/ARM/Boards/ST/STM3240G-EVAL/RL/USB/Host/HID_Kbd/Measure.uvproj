# Keil uVision project Measure.uvproj, settings and files
target STM32F407 OTG_FS (ARM-ADS)
  device: STM32F407IG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: Measure
  c flags: Optim=4
  c define: __STM_EVAL
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Startup
    ./: startup_stm32f40_41xxx.s system_stm32f4xx.c
  group Configuration
    ./: usb_config.c
  group Retarget
    ./: Retarget.c
  group Application
    ./: Measure.c Mcommand.c Getline.c usbh_stm32f40x.c GLCD_16bitIF_STM32F4xx.c
  group Library
    C:/Keil/ARM/RV31/LIB/: USB_CM3.lib
  group Documentation
    ./: Abstract.txt
