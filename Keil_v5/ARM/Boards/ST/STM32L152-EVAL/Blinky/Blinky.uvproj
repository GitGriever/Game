# Keil uVision project Blinky.uvproj, settings and files
target STM32L152 RAM (ARM-ADS)
  device: STM32L152VB STMicroelectronics
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Blinky
  c flags: Optim=1
  c define: STM32L1XX_MD VECT_TAB_SRAM __USE_LCD
  library: MicroLIB
  memory RVCT4: ROM 0x20000000 size 0x3800
  memory RVCT9: RAM 0x20003800 size 0x800
  group StartUp
    ./: startup_stm32l1xx_md.s system_stm32l1xx.c
  group Flash OPT
    ./: STM32L1xx_MD_OPT.s
  group Source Files
    ./: GLCD_SPI_STM32L.c LCD_STM32L.c Retarget.c Serial.c LED.c ADC.c IRQ.c Blinky.c
  group Documentation
    ./: Abstract.txt
target STM32L152 Flash (ARM-ADS)
  device: STM32L152VB STMicroelectronics
  cpu: as above
  output: Blinky
  c flags: Optim=1
  c define: STM32L1XX_MD __USE_LCD
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
target STM32L152 OPT (ARM-ADS)
  device: STM32L152VB STMicroelectronics
  cpu: as above
  output: Blinky
  c flags: Optim=1
  c define: STM32L1XX_MD __USE_LCD
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
target STM32L152 Trace (ARM-ADS)
  device: STM32L152VB STMicroelectronics
  cpu: as above
  output: Blinky
  c flags: Optim=1
  c define: STM32L1XX_MD __USE_LCD
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
