# Keil uVision project FTP_demo.uvproj, settings and files
target MK53N512 (ARM-ADS)
  device: MK53N512CMD100 Freescale Semiconductor
  cpu: IRAM(0x1FFF0000-0x1FFFFFFF) IRAM2(0x20000000-0x2000FFFF) IROM(0x0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") ELITTLE
  output: FTP_demo
  c flags: Optim=4
  c include: ..\Library
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x10000
  group Source Files
    ./: FTP_demo.c FTP_uif.c
  group Configuration Files
    ./: Net_Config.c Net_Debug.c File_Config.c Retarget.c startup_MK53N512ZCMD100.s
  group Library
    C:/Keil/ARM/RV31/LIB/: TCP_CM3.lib TCPD_CM3.lib FS_CM3.lib
    ../Library/: system_MK53N512ZCMD100.c ENET_MKxx.c SDHC_MKxx.c LED.c SER.c
  group Documentation
    ./: Abstract.txt
target MK53N512 Debug (ARM-ADS)
  device: MK53N512CMD100 Freescale Semiconductor
  cpu: as above
  output: FTP_demo
  c flags: Optim=4
  c define: DEBUG
  c include: ..\Library;.\SRC
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x10000
