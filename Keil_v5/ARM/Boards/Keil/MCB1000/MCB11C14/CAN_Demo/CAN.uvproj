# Keil uVision project CAN.uvproj, settings and files
target LPC11C14 RAM (ARM-ADS)
  device: LPC11C14/301 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10001FFF) IROM(0-0x7FFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: CANDemo
  c flags: Optim=1
  c include: .\
  library: MicroLIB
  memory RVCT4: ROM 0x10000000 size 0x1c00
  memory RVCT9: RAM 0x10001c00 size 0x400
  group StartUp
    ./: startup_LPC11xx.s system_LPC11xx.c
  group Source Files
    ./: Retarget.c Serial.c ADC.c LED.c CAN.c CanDemo.c
  group Documentation
    ./: Abstract.txt
target LPC11C14 Flash (ARM-ADS)
  device: LPC11C14/301 NXP (founded by Philips)
  cpu: as above
  output: CANDemo
  c flags: Optim=1
  c include: .\
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x2000
