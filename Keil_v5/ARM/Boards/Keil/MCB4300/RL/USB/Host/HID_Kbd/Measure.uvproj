# Keil uVision project Measure.uvproj, settings and files
target LPC4357 Flash (ARM-ADS)
  device: LPC4350 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x1001FFFF) IRAM2(0x20000000-0x2000FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") FPU2
  output: Measure
  AfterMake: $K\ARM\BIN\ElfDwT.exe !L BASEADDRESS(0x1A000000)
  c flags: Optim=4
  library: MicroLIB
  memory RVCT4: ROM 0x1a000000 size 0x80000
  memory RVCT5: ROM 0x1b000000 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x10000
  group Startup
    ./: startup_LPC43xx.s system_LPC43xx.c
  group Configuration
    ./: usb_config.c
  group Retarget
    ./: Retarget.c
  group Application
    ./: Measure.c Mcommand.c usbh_ehci_lpc43xx.c Getline.c Serial.c GLCD_LPC43xx.c ADC_LPC43xx.c
  group Library
    C:/Keil/ARM/RV31/LIB/: USB_CM3.lib
  group Documentation
    ./: Abstract.txt
target LPC4350 Ext. Flash (ARM-ADS)
  device: LPC4350 NXP (founded by Philips)
  cpu: as above
  output: Measure
  c flags: Optim=4
  library: MicroLIB
  memory RVCT1: ROM 0x1c000000 size 0x1000000
  memory RVCT9: RAM 0x10000000 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x10000
target LPC4350 RAM (ARM-ADS)
  device: LPC4350 NXP (founded by Philips)
  cpu: as above
  output: Measure
  c flags: Optim=4
  library: MicroLIB
  memory RVCT4: ROM 0x10000000 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x10000
