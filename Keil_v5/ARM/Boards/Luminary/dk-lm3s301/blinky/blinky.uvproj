# Keil uVision project blinky.uvproj, settings and files
target blinky (ARM-ADS)
  device: LM3S301 Luminary Micro
  cpu: IRAM(0x20000000-0x200007FF) IROM(0-0x3FFF) CLOCK(6000000) CPUTYPE("Cortex-M3")
  output: blinky
  AfterMake: fromelf --bin --output .\rvmdk\blinky.bin .\rvmdk\blinky.axf
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: rvmdk PART_LM3S301
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x800
  link misc: --entry Reset_Handler
  group Source
    ./: blinky.c startup_rvmdk.S
  group Documentation
    ./: readme.txt
