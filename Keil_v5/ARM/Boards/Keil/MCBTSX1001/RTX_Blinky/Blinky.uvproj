# Keil uVision project Blinky.uvproj, settings and files
target TSX1001 Flash (ARM-ADS)
  device: TSX-1001 Triad Semiconductor
  cpu: IRAM(0x20000000-0x20005FFF) IROM(0x0000000-0x0007FFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: Blinky
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x6000
  group StartUp
    ./: startup_TSX1001.s system_TSX1001.c
  group RTX Configuration
    ./: RTX_Conf_CM.c
  group Source Files
    ./: GLCD_SPI_TSX1001.c LED.c Blinky.c
  group Documentation
    ./: Abstract.txt
target TSX1001 RAM (ARM-ADS)
  device: TSX-1001 Triad Semiconductor
  cpu: as above
  output: Blinky
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x20000000 size 0x4000
  memory RVCT9: RAM 0x20004000 size 0x2000
