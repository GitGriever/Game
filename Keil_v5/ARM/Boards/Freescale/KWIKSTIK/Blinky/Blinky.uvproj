# Keil uVision project Blinky.uvproj, settings and files
target JLink - Flash (ARM-ADS)
  device: MK40X256VMD100 Freescale Semiconductor
  cpu: IRAM(0x1FFF8000-0x1FFFFFFF) IRAM2(0x20000000-0x20007FFF) IROM(0x0-0x3FFFF) IROM2(0x10000000-0x1003FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE
  output: Blinky
  c flags: Optim=1
  c include: .\library\slcd;.\library\tsi;.\library\KWIKSTIK_SCLD
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x10000000 size 0x40000
  memory RVCT9: RAM 0x1fff8000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x8000
  group StartUp
    ./: startup_MK40N512MD100.s system_MK40N512MD100.c
  group Source Files
    ./: Blinky.c SLCD_Driver.c
  group Documentation
    ./: Abstract.txt
target JLink - RAM (ARM-ADS)
  device: MK40X256VMD100 Freescale Semiconductor
  cpu: as above
  output: Blinky
  c flags: Optim=1
  c include: .\library\slcd;.\library\tsi;.\library\KWIKSTIK_SCLD
  library: MicroLIB
  memory RVCT4: ROM 0x1fff8000 size 0x8000
  memory RVCT5: ROM 0x10000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
