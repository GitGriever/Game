# Keil uVision project CAN_Ex2.uvproj, settings and files
target K40X256 (ARM-ADS)
  device: MK40X256VMD100 Freescale Semiconductor
  cpu: IRAM(0x1FFF8000-0x1FFFFFFF) IRAM2(0x20000000-0x20007FFF) IROM(0x0-0x3FFFF) IROM2(0x10000000-0x1003FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") ELITTLE
  output: CAN_Ex2
  c flags: Optim=4
  c include: .\
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x10000000 size 0x40000
  memory RVCT9: RAM 0x1fff8000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x8000
  group StartUp
    ./: startup_MK40N512MD100.s system_MK40N512MD100.c
  group RTX Configuration
    ./: RTX_Config.c
  group CAN Core
    ./: CAN_Cfg.h
    C:/Keil/ARM/RL/CAN/SRC/: RTX_CAN.c
  group CAN Driver
    ./: CAN_MK40.c
  group Source
    ./: CAN_Ex2.c ADC.c LED.c
  group Documentation
    ./: Abstract.txt
