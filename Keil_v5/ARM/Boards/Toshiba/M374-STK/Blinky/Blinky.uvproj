# Keil uVision project Blinky.uvproj, settings and files
target TMPM374 RAM (ARM-ADS)
  device: TMPM374FWUG Toshiba
  cpu: IRAM(0x20000000-0x200017FF) IROM(0-0x0001FFFF) CLOCK(10000000) CPUTYPE("Cortex-M3")
  output: Blinky
  c flags: Optim=1
  memory RVCT4: ROM 0x20000000 size 0x1600
  memory RVCT9: RAM 0x20001600 size 0x200
  group StartUp
    ./: startup_TMPM374.s system_TMPM374.c
  group Source Files
    ./: Retarget.c Serial.c LED.c Blinky.c
  group Documentation
    ./: Abstract.txt
target TMPM374 Flash (ARM-ADS)
  device: TMPM374FWUG Toshiba
  cpu: as above
  output: Blinky
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x1800
target TMPM374 SWO (ARM-ADS)
  device: TMPM374FWUG Toshiba
  cpu: as above
  output: Blinky
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x1800
