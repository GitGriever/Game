# Keil uVision project Smpl_NUTINY_M051.uvproj, settings and files
target Smpl_NUTINY_100 (ARM-ADS)
  device: M0516LAN Nuvoton
  cpu: IRAM(0x20000000-0x20000FFF) IROM(0-0x0FFFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: Smpl_NUTINY_100
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=1 OneElfS=1
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x1000
  link misc: --map --first='startup_M051Series.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS files
    ./: system_M051Series.c startup_M051Series.s
  group Source files
    ./: Smpl_LED.c
  group Documentation
    ./: Abstract.txt
