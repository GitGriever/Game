# Keil uVision project Blinky.uvproj, settings and files
target Simulator (ARM-ADS)
  device: TMPM330FDFG Toshiba
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x7FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Blinky
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group System Files
    ./: startup_TMPM330.s system_TMPM330.c
  group Source Files
    ./: Blinky.c Retarget.c Serial.c IRQ.c
  group Trace Configuration
    ./: TMPM330_TP.ini
  group Documentation
    ./: Abstract.txt
target RAM (ARM-ADS)
  device: TMPM330FDFG Toshiba
  cpu: as above
  output: Blinky
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x20000000 size 0x4000
  memory RVCT9: RAM 0x20004000 size 0x4000
target SWO Trace (ARM-ADS)
  device: TMPM330FDFG Toshiba
  cpu: as above
  output: Blinky
  c flags: Optim=1
  c define: __DBG_ITM
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x8000
target TracePort Trace (ARM-ADS)
  device: TMPM330FDFG Toshiba
  cpu: as above
  output: Blinky
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x8000
target TracePort InstructionTrace (ARM-ADS)
  device: TMPM330FDFG Toshiba
  cpu: as above
  output: Blinky
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x8000
