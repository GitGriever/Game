# Keil uVision project Smpl_NUTINY_122.uvproj, settings and files
target Smpl_NUTINY_122 (ARM-ADS)
  device: NUC122LD2AN Nuvoton
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0-0x0FFFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: Smpl_NUTINY_122
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=1 OneElfS=1
  c include: ..\Include;..\Include\Driver
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --map --first='startup_NUC122.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS files
    ./: system_NUC122.c startup_NUC122.s
  group Source files
    ./: Smpl_NUTINY_122.c
  group Library files
    ../Src/Driver/: DrvGPIO.c DrvUART.c DrvSYS.c retarget.c
  group Documentation
    ./: Abstract.txt
target TEST (ARM-ADS)
  device: NUC122LD2AN Nuvoton
  cpu: as above
  output: Smpl_NUTINY_122
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=1 OneElfS=1
  c include: .\;..\Include;..\Include\Driver
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: as above
