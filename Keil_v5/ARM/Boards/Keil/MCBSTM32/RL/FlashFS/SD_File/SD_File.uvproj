# Keil uVision project SD_File.uvproj, settings and files
target MCBSTM32 (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: SD_File
  c flags: Optim=1
  c define: STM32F10X_MD
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group StartUp
    ./: startup_stm32f10x_md.s system_stm32f10x.c
  group Source Files
    ./: SD_File.c Getline.c
  group Configuration Files
    ./: File_Config.c SPI_STM32F103.c
  group Com Port
    ./: Serial.c Retarget.c
  group Library
    ./: LCD_4bit.c
    C:/Keil/ARM/RV31/LIB/: FS_CM3.lib
  group Documentation
    ./: Abstract.txt
