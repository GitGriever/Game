# Keil uVision project Blinky.uvproj, settings and files
target MB9AFB44N RAM (ARM-ADS)
  device: MB9AFB44NA Fujitsu Semiconductor
  cpu: IRAM(0x20000000-0x20003FFF) IRAM2(0x1FFFC000-0x1FFFFFFF) IROM(0x00000000-0x0003FFFF) IROM2(0x00200000-0x00207FFF) CLOCK(4000000) CPUTYPE("Cortex-M3")
  output: Blinky
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x1fffc000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group StartUp
    ./: startup_mb9afb4x.s system_mb9afb4x.c
  group RTX Configuration
    ./: RTX_Conf_CM.c
  group Source Files
    ./: LED.c Blinky.c
  group Documentation
    ./: Abstract.txt
target MB9AFB44N Flash (ARM-ADS)
  device: MB9AFB44NA Fujitsu Semiconductor
  cpu: as above
  output: Blinky
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x200000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x4000
  memory RVCT10: RAM 0x1fffc000 size 0x4000
