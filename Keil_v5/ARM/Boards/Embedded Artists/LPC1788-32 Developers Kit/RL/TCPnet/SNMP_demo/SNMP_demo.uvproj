# Keil uVision project SNMP_demo.uvproj, settings and files
target LPC1788 (ARM-ADS)
  device: LPC1788 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x1000FFFF) IRAM2(0x20000000-0x20007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: SNMP_demo
  c flags: Optim=4
  c include: ..\Library
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x8000
  group Source Files
    ./: SNMP_demo.c SNMP_MIB.c
  group Configuration Files
    ./: Net_Config.c Net_Debug.c startup_LPC177x_8x.s
  group Library
    C:/Keil/ARM/RV31/LIB/: TCP_CM3.lib TCPD_CM3.lib
    ../Library/: EMAC_LPC177x_8x.c system_LPC177x_8x.c Serial_LPC177x_8x.c KBD_LPC177x_8x.c LED_LPC177x_8x.c I2C_LPC177x_8x.c
  group Documentation
    ./: Abstract.txt
target LPC1788 Debug (ARM-ADS)
  device: LPC1788 NXP (founded by Philips)
  cpu: as above
  output: SNMP_demo
  c flags: Optim=4
  c include: ..\Library
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x8000
