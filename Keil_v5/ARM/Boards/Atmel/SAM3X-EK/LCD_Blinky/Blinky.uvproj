# Keil uVision project Blinky.uvproj, settings and files
target SAM3X Flash (ARM-ADS)
  device: SAM3X8H Atmel
  cpu: IRAM(0x20000000-0x2000FFFF) IRAM2(0x20080000-0x20087FFF) IROM(0x80000-0xFFFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: Blinky
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x80000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x20080000 size 0x8000
  group StartUp
    ./: startup_SAM3XA.s system_SAM3XA.c
  group Pictures
    ./: ARM_Ani_16bpp.c Bg_16bpp_b.c Bg_16bpp_l.c Bg_16bpp_r.c Bg_16bpp_t.c
  group Source Files
    ./: GLCD_16bitIF_SAM3X.c LED.c IRQ.c Blinky.c
  group Documentation
    ./: Abstract.txt
