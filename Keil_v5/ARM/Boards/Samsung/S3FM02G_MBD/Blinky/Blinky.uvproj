# Keil uVision project Blinky.uvproj, settings and files
target S3FM02G - Flash (ARM-ADS)
  device: S3FM02G Samsung
  cpu: IRAM(0x20000000-0x20005FFF) IROM(0-0x5FFFF) IROM2(0x80000000-0x80003FFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Blinky
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x60000
  memory RVCT5: ROM 0x80000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x6000
  group System File
    ./: system_S3FM02G.c startup_s3fm02g.s
  group Source Code
    ./: Blinky.c
  group Smart Option
    ./: s3fm02g_sopt.s
  group Documentation
    ./: Abstract.txt
target S3FM02G - Flash + Smart Opt (ARM-ADS)
  device: S3FM02G Samsung
  cpu: as above
  output: Blinky
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x60000
  memory RVCT5: ROM 0x80000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x6000
target S3FM02G - RAM (ARM-ADS)
  device: S3FM02G Samsung
  cpu: as above
  output: Blinky
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x20000000 size 0x2000
  memory RVCT5: ROM 0x80000000 size 0x4000
  memory RVCT9: RAM 0x20002000 size 0x4000
