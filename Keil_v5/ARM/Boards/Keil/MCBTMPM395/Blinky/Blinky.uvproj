# Keil uVision project Blinky.uvproj, settings and files
target MCBTMPM395 Flash (ARM-ADS)
  device: TMPM395FWAXBG Toshiba
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0-0x1FFFF) CLOCK(20000000) CPUTYPE("Cortex-M3")
  output: Blinky
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group StartUp
    ./: startup_TMPM395.s system_TMPM395.c
  group Source Code
    ./: Blinky.c BTN.c LED.c ADC.c
  group Documentation
    ./: Abstract.txt
target MCBTMPM395 RAM (ARM-ADS)
  device: TMPM395FWFXG Toshiba
  cpu: as above
  output: Blinky
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x20000000 size 0x1000
  memory RVCT9: RAM 0x20001000 size 0x1000
target MCBTMPM359 Trace (ARM-ADS)
  device: TMPM395FWFXG Toshiba
  cpu: as above
  output: Blinky
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
