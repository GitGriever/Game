# Keil uVision project ADUCMxxx.uvproj, settings and files
target ADuCRF101 (ARM-ADS)
  device: ADuCRF101 Analog Devices
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0x0000000-0x001FFFF) CLOCK(16000000) CPUTYPE("Cortex-M3")
  output: ADUCMxxx
  AfterMake: cmd.exe /C copy ADUCMxxx.axf ..\ADUCMxxx.FLM
  c flags: Optim=1
  c define: ADuCRF101
  c include: .\;..\..\INC
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
  group Program Functions
    ./: FlashPrg.c
  group Device Description
    ./: FlashDev.c
target ADuCMxxx (ARM-ADS)
  device: ADuCRF101 Analog Devices
  cpu: as above
  output: ADUCMxxx
  AfterMake: cmd.exe /C copy ADUCMxxx.axf ..\ADUCMxxx_128.FLM
  c flags: Optim=1
  c define: ADuCMxxx_128
  c include: .\;..\..\INC
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
