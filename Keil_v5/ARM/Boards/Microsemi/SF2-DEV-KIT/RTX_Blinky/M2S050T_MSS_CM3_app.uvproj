# Keil uVision project M2S050T_MSS_CM3_app.uvproj, settings and files
target Cortex-M3 Flash (ARM-ADS)
  device: M2S050T Actel
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x0-0x3FFFF) CLOCK(20000000) CPUTYPE("Cortex-M3")
  output: M2S050T_MSS_CM3_app
  c flags: Optim=1
  c include: ./;./CMSIS;./CMSIS/startup_arm;./drivers;./drivers/mss_gpio;./drivers/mss_hpdma;./drivers/mss_nvm;./drivers/mss_pdma;./drivers/mss_sys_services;./drivers/mss_timer;./drivers/mss_uart;./drivers/mss_watchdog;./drivers_config;./drivers_config/sys_config;./hal;./hal/CortexM3;./hal/CortexM3/Keil
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group CMSIS
    ./CMSIS/startup_arm/: startup_m2sxxx.s retarget.c
    ./CMSIS/: system_m2sxxx.c
  group RTX Configuration
    ./: RTX_Conf_CM.c
  group Source Files
    ./: LED.c Blinky.c
  group Library Files
    ./obj/: M2S050T_MSS_CM3_hw_platform.lib
  group Documentation
    ./: Abstract.txt
target Cortex-M3 SRAM (ARM-ADS)
  device: M2S050T Actel
  cpu: as above
  output: M2S050T_MSS_CM3_app
  c flags: Optim=1
  c include: as above
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x20000000 size 0x8000
  memory RVCT9: RAM 0x20008000 size 0x8000
