# Keil uVision project Http_upload.uvproj, settings and files
target SAM3X8H (ARM-ADS)
  device: SAM3X8H Atmel
  cpu: IRAM(0x20000000-0x2000FFFF) IRAM2(0x20080000-0x20087FFF) IROM(0x80000-0xFFFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: Http_upload
  c flags: Optim=4
  c include: ..\Library
  memory RVCT4: ROM 0x80000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x20080000 size 0x8000
  group HTTP Files
    ./Web/: Web.inp index.htm upload.cgi dir.cgi format.cgi pg_footer.inc pg_header.inc
  group Source Files
    ./: HTTP_upload.c HTTP_CGI.c
    ./Web/: WEB.C
  group Configuration Files
    ./: Net_Config.c File_Config.c HTTP_uif.c Retarget.c startup_SAM3XA.s
  group Library
    C:/Keil/ARM/RV31/LIB/: TCP_CM3.lib FS_CM3.lib
    ../Library/: system_SAM3XA.c EMAC_SAM3X.c MCI_SAM3X.c LED.c GLCD_16bitIF_SAM3X.c
  group Documentation
    ./: Abstract.txt
