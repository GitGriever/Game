# Keil uVision project M29W640FBx2.uvproj, settings and files
target M29W640FBx2 (ARM-ADS)
  device: LPC1850 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10017FFF) IRAM2(0x20000000-0x2000FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: M29W640FBx2
  AfterMake: cmd.exe /C copy M29W640FBx2.axf ..\M29W640FBx2.FLM
  c flags: Optim=3
  memory RVCT9: RAM 0x10000000 size 0x18000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
  group Program Functions
    ./: FlashPrg.c
  group Device Description
    ./: FlashDev.c
