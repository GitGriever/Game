# Keil uVision project MSD_File.uvproj, settings and files
target K60F120M (ARM-ADS)
  device: MK60FN1M0xxx12 Freescale Semiconductor
  cpu: IRAM(0x1FFF0000-0x1FFFFFFF) IRAM2(0x20000000-0x2000FFFF) IROM(0x0-0xFFFFF) CLOCK(12000000) CPUTYPE("Cortex-M4")  FPU2 ELITTLE
  output: MSD_File
  c flags: Optim=4
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x10000
  group Startup
    ./: startup_MK60F12.s system_MK60F12.c
  group Configuration
    ./: File_Config.c usb_config.c
  group Retarget
    ./: Retarget.c
  group Application
    ./: MSD_File.c Getline.c SER.c fs_usbh_msc.c usbh_MK60F12.c
  group Library
    C:/Keil/ARM/RV31/LIB/: FS_CM3.lib USB_CM3.lib
  group Documentation
    ./: Abstract.txt
