# Keil uVision project Memory.uvproj, settings and files
target MK60 RTX (ARM-ADS)
  device: MK60N512VMD100 Freescale Semiconductor
  cpu: IRAM(0x1FFF0000-0x1FFFFFFF) IRAM2(0x20000000-0x2000FFFF) IROM(0x0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE
  output: Memory
  c flags: Optim=4
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x10000
  group Startup Code
    ./: startup_MK60N512MD100.s system_MK60N512MD100.c SVC_Table.s
  group Configuration
    ./: usb_config.c RTX_Conf_CM.c
  group USB HW Driver
    ./: usbd_MKxx.c
  group Source
    ./: USBD_Demo.c usbd_user_msc.c DiskImg.c
  group Library
    C:/Keil/ARM/RV31/LIB/: USB_CM3.lib
  group Documentation
    ./: Abstract.txt
