# Keil uVision project Memory.uvproj, settings and files
target XMC4500_RTX (ARM-ADS)
  device: XMC4500-1024 Infineon
  cpu: IRAM(0x20000000-0x2000FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x0C000000-0x0C0FFFFF) IROM2(0x08000000-0x080FFFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") FPU2
  output: Memory
  c flags: Optim=4
  memory RVCT4: ROM 0xc000000 size 0x100000
  memory RVCT5: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Startup Code
    ./: startup_XMC4500.s System_XMC4500.c SVC_Table.s
  group Configuration
    ./: usb_config.c RTX_Config.c
  group USB HW Driver
    ./: usbd_xmc4500.c
  group Source
    ./: usbd_user_msc.c SDMMC_XMC4500.c Memory.c File_Config.c Retarget.c
  group Library
    C:/Keil/ARM/RV31/LIB/: USB_CM3.lib FS_CM3.lib
  group Documentation
    ./: Abstract.txt
