# Keil uVision project Blinky.uvproj, settings and files
target S3FN429 - Flash (ARM-ADS)
  device: S3FN429 Samsung
  cpu: IRAM(0x20000000-0x200007FF) IROM(0-0x7FFF) CLOCK(4000000) CPUTYPE("Cortex-M0") ELITTLE
  output: Blinky
  c flags: Optim=4
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x800
  group System File
    ./: system_s3fn429.c startup_s3fn429.s
  group Source Code
    ./: Blinky.c
  group Documentation
    ./: Abstract.txt
target S3FN429 - Flash + Smart Opt (ARM-ADS)
  device: S3FN429 Samsung
  cpu: as above
  output: Blinky
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x800
