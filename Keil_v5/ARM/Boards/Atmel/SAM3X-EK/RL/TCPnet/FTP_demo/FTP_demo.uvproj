# Keil uVision project FTP_demo.uvproj, settings and files
target SAM3X8H (ARM-ADS)
  device: SAM3X8H Atmel
  cpu: IRAM(0x20000000-0x2000FFFF) IRAM2(0x20080000-0x20087FFF) IROM(0x80000-0xFFFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: FTP_demo
  c flags: Optim=4
  c include: ..\Library
  memory RVCT4: ROM 0x80000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x20080000 size 0x8000
  group Source Files
    ./: FTP_demo.c FTP_uif.c
  group Configuration Files
    ./: Net_Config.c Net_Debug.c File_Config.c Retarget.c startup_SAM3XA.s
  group Library
    C:/Keil/ARM/RV31/LIB/: TCP_CM3.lib TCPD_CM3.lib FS_CM3.lib
    ../Library/: system_SAM3XA.c EMAC_SAM3X.c MCI_SAM3X.c LED.c SER.c GLCD_16bitIF_SAM3X.c
  group Documentation
    ./: Abstract.txt
target SAM3X8H Debug (ARM-ADS)
  device: SAM3X8H Atmel
  cpu: as above
  output: FTP_demo
  c flags: Optim=4
  c define: DEBUG
  c include: ..\Library
  memory RVCT4: ROM 0x80000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x20080000 size 0x8000
