# Keil uVision project Blinky.uvproj, settings and files
target LPC4088 RAM (ARM-ADS)
  device: LPC4088 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x1000FFFF) IRAM2(0x20000000-0x20007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") FPU2
  output: Blinky
  c flags: Optim=1
  c define: CORE_M4 __RAM_MODE__
  library: MicroLIB
  memory RVCT4: ROM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x8000
  group StartUp
    ./: startup_LPC407x_8x_177x_8x.s system_LPC407x_8x_177x_8x.c
  group RTX Configuration
    ./: RTX_Conf_CM.c
  group Source Files
    ./: LED.c Blinky.c
  group Documentation
    ./: Abstract.txt
target LPC4088 Flash (ARM-ADS)
  device: LPC4088 NXP (founded by Philips)
  cpu: as above
  output: Blinky
  c flags: Optim=1
  c define: CORE_M4
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x8000
