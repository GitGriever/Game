# Keil uVision project Blinky.uvproj, settings and files
target SWO Trace (ARM-ADS)
  device: STM32F407IG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: Blinky
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group StartUp
    ./: startup_stm32f40_41xxx.s system_stm32f4xx.c
  group Source Files
    ./: Retarget.c Serial.c LED.c ADC_ULp.c IRQ.c Blinky.c
  group Trace Configuration
    ./: STM32_SWO.ini STM32F4xx_TP.ini
  group Documentation
    ./: Abstract.txt
target TracePort Trace (ARM-ADS)
  device: STM32F407IG STMicroelectronics
  cpu: as above
  output: Blinky
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
target TracePort Instruction Trace (ARM-ADS)
  device: STM32F407IG STMicroelectronics
  cpu: as above
  output: Blinky
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
