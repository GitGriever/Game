# Keil uVision project Hello.uvproj, settings and files
target SN32F109 Flash JLink (ARM-ADS)
  device: SN32F109 SONiX
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x0-0xFFFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: Hello
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group StartUp
    ./: startup_SN32F100.s system_SN32F100.c
  group Source Files
    ./: Retarget.c Serial.c Hello.c
  group Documentation
    ./: Abstract.txt
target SN32F109 Flash (ARM-ADS)
  device: SN32F109 SONiX
  cpu: as above
  output: Hello
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
target SN32F109 RAM (ARM-ADS)
  device: SN32F109 SONiX
  cpu: as above
  output: Hello
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x20000000 size 0x1000
  memory RVCT9: RAM 0x20001000 size 0x1000
