# Keil uVision project CM4P1_Blinky.uvproj, settings and files
target SAM4C_CM4P1 (ARM-ADS)
  device: SAM4C16C CM4P1 Atmel
  cpu: IRAM(0x20100000-0x20101FFF) IROM(0x0-0x3FFF) CLOCK(12000000) CPUTYPE("Cortex-M4") FPU2
  output: CM4P1_Blinky
  AfterMake: fromelf --cadcombined --output="..\CM4P0\CM4P1_Image.c" "!L"
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x4000
  memory RVCT9: RAM 0x20100000 size 0x2000
  group StartUp
    ./: startup_SAM4C.s system_SAM4C.c
  group Source Files
    ./: LED.c CM4P1_Blinky.c
  group Documentation
    ./: Abstract.txt
