# Keil uVision project DHRY.uvproj, settings and files
target Simulator (ARM-ADS)
  device: STM32F103VB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: DHRY
  c flags: Optim=1
  c define: MSC_CLOCK STM32F10X_MD
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group StartUp
    ./: startup_stm32f10x_md.s system_stm32f10x.c
  group System Calls
    ./: Retarget.c Serial.c Time.c
  group Source Code
    ./: dhry_1.c dhry_2.c
  group Documentation
    ./: Abstract.txt
target STM32F103 Flash (ARM-ADS)
  device: STM32F103VB STMicroelectronics
  cpu: as above
  output: DHRY
  c flags: Optim=1
  c define: MSC_CLOCK STM32F10X_MD
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
