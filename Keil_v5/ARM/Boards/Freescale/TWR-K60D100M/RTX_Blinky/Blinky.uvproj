# Keil uVision project Blinky.uvproj, settings and files
target ULink-Flash (ARM-ADS)
  device: MK60DN512xxx10 Freescale Semiconductor
  cpu: IRAM(0x1FFF0000-0x1FFFFFFF) IRAM2(0x20000000-0x2000FFFF) IROM(0x0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") ELITTLE
  output: Blinky
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x10000
  group StartUp
    ./: system_MK60D10.c startup_MK60D10.s
  group Source Files
    ./: Blinky.c
  group RTX Configuration
    ./: RTX_Conf_CM.c
  group Documentation
    ./: Abstract.txt
target ULink-RAM (ARM-ADS)
  device: MK60DN512xxx10 Freescale Semiconductor
  cpu: as above
  output: Blinky
  c flags: Optim=1
  memory RVCT4: ROM 0x1fff0000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x10000
target ULinkPro-Flash (ARM-ADS)
  device: MK60DN512xxx10 Freescale Semiconductor
  cpu: as above
  output: Blinky
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x10000
target ULinkPro-RAM (ARM-ADS)
  device: MK60DN512xxx10 Freescale Semiconductor
  cpu: as above
  output: Blinky
  c flags: Optim=1
  memory RVCT4: ROM 0x1fff0000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x10000
