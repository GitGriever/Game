# Keil uVision project Blinky.uvproj, settings and files
target ULink - Flash (ARM-ADS)
  device: MK64FN1M0xxx12 Freescale Semiconductor
  cpu: IRAM(0x1FFF0000-0x1FFFFFFF) IRAM2(0x20000000-0x2002FFFF) IROM(0x0-0xFFFFF) CLOCK(12000000) CPUTYPE("Cortex-M4")  FPU2 ELITTLE
  output: Blinky
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x30000
  group Startup
    ./: system_MK64F12.c startup_MK64F12.s
  group RTX_Configuration
    ./: RTX_Conf_CM.c
  group Source Files
    ./: Blinky.c
  group Documentation
    ./: Abstract.txt
target ULink - RAM (ARM-ADS)
  device: MK64FN1M0xxx12 Freescale Semiconductor
  cpu: as above
  output: Blinky
  c flags: Optim=1
  memory RVCT4: ROM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x30000
