# Keil uVision project Memory.uvproj, settings and files
target STM32F407 Flash (ARM-ADS)
  device: STM32F407IG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: Memory
  c flags: Optim=4
  c define: __STM_EVAL __DBG_ITM
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Startup Code
    ./: startup_stm32f40_41xxx.s system_stm32f4xx.c SVC_Table.s
  group Configuration
    ./: File_Config.c usb_config_HS.c RTX_Conf_CM.c
  group Drivers
    ./: LED.c KBD.c Serial.c GLCD_16bitIF_STM32F4xx.c SDIO_STM32F4xx.c
  group File System
    ./: Retarget.c
    C:/Keil/ARM/RV31/LIB/: FS_CM3.lib
  group USB
    C:/Keil/ARM/RV31/LIB/: USB_CM3.lib
    ./: usbd_STM32F4xx_HS.c usbd_user_msc.c
  group Main Code
    ./: Getline.c SD_File.c Memory.c
  group Documentation
    ./: Abstract.txt
