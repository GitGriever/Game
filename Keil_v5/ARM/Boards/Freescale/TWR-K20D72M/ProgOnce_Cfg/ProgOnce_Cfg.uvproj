# Keil uVision project ProgOnce_Cfg.uvproj, settings and files
target ProgOnce_Cfg - ULINK (ARM-ADS)
  device: MK20DX256xxx7 Freescale Semiconductor
  cpu: IRAM(0x1FFF8000-0x1FFFFFFF) IRAM2(0x20000000-0x20007FFF) IROM(0x0-0x3FFFF) IROM2(0x10000000-0x10007FFF) CLOCK(12000000) CPUTYPE("Cortex-M4") ELITTLE
  output: ProOnceMem
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x10000000 size 0x8000
  memory RVCT9: RAM 0x1fff8000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x8000
  scatter file: .\scatter\ProgOnce.sct
  group Program Once Memory
    ./: MKxxFlashIFR.s
  group Documentation
    ./: Abstract.txt
target ProgOnce_Cfg - ULINKPro (ARM-ADS)
  device: MK20DX256xxx7 Freescale Semiconductor
  cpu: as above
  output: ProOnceMem
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x10000000 size 0x8000
  memory RVCT9: RAM 0x1fff8000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x8000
  scatter file: .\scatter\ProgOnce.sct
