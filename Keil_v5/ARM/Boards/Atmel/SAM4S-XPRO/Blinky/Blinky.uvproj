# Keil uVision project Blinky.uvproj, settings and files
target SAM4S RAM (ARM-ADS)
  device: SAM4SD32C Atmel
  cpu: IRAM(0x20000000-0x20027FFF) IROM(0x400000-0x4FFFFF) IROM2(0x500000-0x5FFFFF) CLOCK(12000000) CPUTYPE("Cortex-M4")
  output: Blinky
  c flags: Optim=1
  c define: __UART
  library: MicroLIB
  memory RVCT4: ROM 0x20000000 size 0x20000
  memory RVCT5: ROM 0x500000 size 0x100000
  memory RVCT9: RAM 0x20020000 size 0x8000
  group StartUp
    ./: startup_SAM4S.s system_SAM4S.c
  group SourceFiles
    ./: Retarget.c Serial.c LED.c BTN.c Blinky.c
  group Documentation
    ./: Abstract.txt
target SAM4S Flash (ARM-ADS)
  device: SAM4SD32C Atmel
  cpu: as above
  output: Blinky
  c flags: Optim=1
  c define: __UART
  library: MicroLIB
  memory RVCT4: ROM 0x400000 size 0x100000
  memory RVCT5: ROM 0x500000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x28000
