# Keil uVision project S3FN429.uvproj, settings and files
target S3FN429 PFlash (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: S3FN429_PFLASH
  AfterMake: cmd.exe /C copy Output\S3FN429_PFLASH.axf ..\S3FN429_PFLASH.FLM
  c flags: Optim=3
  c define: S3FN429_PFLASH
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x800
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
  group Program Functions
    ./: FlashPrg.c
  group Device Description
    ./: FlashDev.c
target S3FN429 SOPT (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: S3FN429_SOPT
  AfterMake: cmd.exe /C copy Output\S3FN429_SOPT.axf ..\S3FN429_SOPT.FLM
  c flags: Optim=3
  c define: S3FN429_SOPT
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x800
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
