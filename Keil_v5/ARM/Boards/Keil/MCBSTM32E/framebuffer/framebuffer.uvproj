# Keil uVision project framebuffer.uvproj, settings and files
target MCBSTM32E (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: framebuffer
  c flags: Optim=1
  c define: STM32F10X_HD
  c include: ./src/cmsis/
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group StartUp
    ./src/cmsis/: startup_stm32f10x_hd.s system_stm32f10x.c
  group App
    ./src/: main.c application.c picture.c
  group System
    ./src/: taskman.c term_ctrl.c drv_glcd0.c RTX_Config.c retarget.c framebuf.c drv_itm.c
  group Low Level Drv
    ./src/: led.c ext_sram.c GLCD.c keyboard.c itm_rx.c
  group Documentation
    ./: Abstract.txt
