# Keil uVision project Blinky.uvproj, settings and files
target STM32F217 RAM (ARM-ADS)
  device: STM32F217IG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: Blinky
  c flags: Optim=1
  c define: VECT_TAB_SRAM
  library: MicroLIB
  memory RVCT4: ROM 0x20000000 size 0x10000
  memory RVCT9: RAM 0x20010000 size 0x10000
  group StartUp
    ./: startup_stm32f2xx.s system_stm32f2xx.c
  group RTX Configuration
    ./: RTX_Conf_CM.c
  group Source Files
    ./: Blinky.c LED.c
  group Documentation
    ./: Abstract.txt
target STM32F217 Flash (ARM-ADS)
  device: STM32F217IG STMicroelectronics
  cpu: as above
  output: Blinky
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
