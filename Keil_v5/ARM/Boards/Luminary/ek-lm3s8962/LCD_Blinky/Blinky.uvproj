# Keil uVision project Blinky.uvproj, settings and files
target Simulator (ARM-ADS)
  device: LM3S8962 Luminary Micro
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0-0x3FFFF) CLOCK(50000000) CPUTYPE("Cortex-M3")
  output: Blinky
  c flags: Optim=1
  c define: rvmdk PART_LM3S8962
  c misc: --diag_suppress 3419
  c include: C:/Keil/ARM/RV31/LIB/Luminary
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Startup Code
    ./: startup_rvmdk.S
  group Source Code
    ./: Blinky.c
  group Library
    ../: rit128x96x4.c
    C:/Keil/ARM/RV31/LIB/Luminary/: driverlib-cm3.lib
  group Documentation
    ./: Abstract.txt
target LM3S8962 Flash (ARM-ADS)
  device: LM3S8962 Luminary Micro
  cpu: as above
  output: Blinky
  c flags: Optim=1
  c define: rvmdk PART_LM3S8962
  c misc: --diag_suppress 3419
  c include: C:/Keil/ARM/RV31/LIB/Luminary
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
