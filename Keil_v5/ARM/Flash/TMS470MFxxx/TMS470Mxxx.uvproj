# Keil uVision project TMS470Mxxx.uvproj, settings and files
target TMS470MF_BANK0_512KB (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3") ESEL ELITTLE
  output: TMS470MF_BANK0_512KB
  AfterMake: cmd.exe cmd.exe /C copy ".\Output\%L" "..\@L.FLM"
  c flags: Optim=3
  c define: TMS470MF_BANK0_512KB, F035, __big_endian__
  c misc: --diag_suppress 3017
  asm misc: --diag_suppress 1608
  scatter file: .\Target.lin
  link misc: --be32 --diag_suppress=6461 --diag_suppress L6305
  group Program Functions
    ./: FlashPrg.c
  group Device Description
    ./: FlashDev.c
  group Flash Library
    ./Flash Library/: pf035a_api_eabi.lib
target TMS470MF_BANK0_384KB (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3") ESEL ELITTLE
  output: TMS470MF_BANK0_384KB
  AfterMake: cmd.exe cmd.exe /C copy ".\Output\%L" "..\@L.FLM"
  c flags: Optim=3
  c define: TMS470MF_BANK0_384KB, F035, __big_endian__
  c misc: --diag_suppress 3017
  asm misc: --diag_suppress 1608
  scatter file: .\Target.lin
  link misc: --be32 --diag_suppress=6461 --diag_suppress L6305
target TMS470MF_BANK0_256KB (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3") ESEL ELITTLE
  output: TMS470MF_BANK0_256KB
  AfterMake: cmd.exe cmd.exe /C copy ".\Output\%L" "..\@L.FLM"
  c flags: Optim=3
  c define: TMS470MF_BANK0_256KB, F035, __big_endian__
  c misc: --diag_suppress 3017
  asm misc: --diag_suppress 1608
  scatter file: .\Target.lin
  link misc: --be32 --diag_suppress=6461 --diag_suppress L6305
target TMS470MF_BANK1_128KB (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3") ESEL ELITTLE
  output: TMS470MF_BANK1_128KB
  AfterMake: cmd.exe cmd.exe /C copy ".\Output\%L" "..\@L.FLM"
  c flags: Optim=3
  c define: TMS470MF_BANK1_128KB, F035, __big_endian__
  c misc: --diag_suppress 3017
  asm misc: --diag_suppress 1608
  scatter file: .\Target.lin
  link misc: --be32 --diag_suppress=6461 --diag_suppress L6305
target TMS470MF_BANK1_64KB (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3") ESEL ELITTLE
  output: TMS470MF_BANK1_64KB
  AfterMake: cmd.exe cmd.exe /C copy ".\Output\%L" "..\@L.FLM"
  c flags: Optim=3
  c define: TMS470MF_BANK1_64KB, F035, __big_endian__
  c misc: --diag_suppress 3017
  asm misc: --diag_suppress 1608
  scatter file: .\Target.lin
  link misc: --be32 --diag_suppress=6461 --diag_suppress L6305
target TMS470MF_BANK0_256KB_ECC (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3") ESEL ELITTLE
  output: TMS470MF_BANK0_256KB_ECC
  AfterMake: cmd.exe cmd.exe /C copy ".\Output\%L" "..\@L.FLM"
  c flags: Optim=3
  c define: TMS470MF_BANK0_256KB_ECC, F035, __big_endian__
  c misc: --diag_suppress 3017
  asm misc: --diag_suppress 1608
  scatter file: .\Target.lin
  link misc: --be32 --diag_suppress=6461 --diag_suppress L6305
target TMS470MF_BANK0_192KB_ECC (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3") ESEL ELITTLE
  output: TMS470MF_BANK0_192KB_ECC
  AfterMake: cmd.exe cmd.exe /C copy ".\Output\%L" "..\@L.FLM"
  c flags: Optim=3
  c define: TMS470MF_BANK0_192KB_ECC, F035, __big_endian__
  c misc: --diag_suppress 3017
  asm misc: --diag_suppress 1608
  scatter file: .\Target.lin
  link misc: --be32 --diag_suppress=6461 --diag_suppress L6305
target TMS470MF_BANK0_128KB_ECC (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3") ESEL ELITTLE
  output: TMS470MF_BANK0_128KB_ECC
  AfterMake: cmd.exe cmd.exe /C copy ".\Output\%L" "..\@L.FLM"
  c flags: Optim=3
  c define: TMS470MF_BANK0_128KB_ECC, F035, __big_endian__
  c misc: --diag_suppress 3017
  asm misc: --diag_suppress 1608
  scatter file: .\Target.lin
  link misc: --be32 --diag_suppress=6461 --diag_suppress L6305
target TMS470MF_BANK1_64KB_ECC (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3") ESEL ELITTLE
  output: TMS470MF_BANK1_64KB_ECC
  AfterMake: cmd.exe cmd.exe /C copy ".\Output\%L" "..\@L.FLM"
  c flags: Optim=3
  c define: TMS470MF_BANK1_64KB_ECC, F035, __big_endian__
  c misc: --diag_suppress 3017
  asm misc: --diag_suppress 1608
  scatter file: .\Target.lin
  link misc: --be32 --diag_suppress=6461 --diag_suppress L6305
target TMS470MF_BANK1_32KB_ECC (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3") ESEL ELITTLE
  output: TMS470MF_BANK1_32KB_ECC
  AfterMake: cmd.exe cmd.exe /C copy ".\Output\%L" "..\@L.FLM"
  c flags: Optim=3
  c define: TMS470MF_BANK1_32KB_ECC, F035, __big_endian__
  c misc: --diag_suppress 3017
  asm misc: --diag_suppress 1608
  scatter file: .\Target.lin
  link misc: --be32 --diag_suppress=6461 --diag_suppress L6305
