# Keil uVision project Blinky.uvproj, settings and files
target SAM4C RAM (ARM-ADS)
  device: SAM4C16C CM4P0 Atmel
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x1000000-0x10FFFFF) CLOCK(12000000) CPUTYPE("Cortex-M4")
  output: Blinky
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x20000000 size 0x10000
  memory RVCT9: RAM 0x20010000 size 0x10000
  group StartUp
    ./: startup_SAM4C.s system_SAM4C.c
  group RTX Configuration
    ./: RTX_Conf_CM.c
  group Source Files
    ./: LED.c Blinky.c
  group Documentation
    ./: Abstract.txt
target SAM4C Flash (ARM-ADS)
  device: SAM4C16C CM4P0 Atmel
  cpu: as above
  output: Blinky
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x1000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
