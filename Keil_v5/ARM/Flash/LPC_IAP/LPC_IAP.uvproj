# Keil uVision project LPC_IAP.uvproj, settings and files
target LPC1XXX_IAP_4 (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: LPC1xxx_4
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=3
  c define: LPC1XXX FLASH_4
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
  group Program Functions
    ./: FlashPrg.c
  group Device Description
    ./: FlashDev.c
target LPC1XXX_IAP_8 (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: LPC1xxx_8
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=3
  c define: LPC1XXX FLASH_8
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target LPC1XXX_IAP_16 (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: LPC1xxx_16
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=3
  c define: LPC1XXX FLASH_16
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target LPC1XXX_IAP_24 (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: LPC1xxx_24
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=3
  c define: LPC1XXX FLASH_24
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target LPC1XXX_IAP_32 (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: LPC1xxx_32
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=3
  c define: LPC1XXX FLASH_32
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target LPC1XXX_IAP_40 (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: LPC1xxx_40
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=3
  c define: LPC1XXX FLASH_40
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target LPC1XXX_IAP_48 (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: LPC1xxx_48
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=3
  c define: LPC1XXX FLASH_48
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target LPC1XXX_IAP_56 (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: LPC1xxx_56
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=3
  c define: LPC1XXX FLASH_56
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target LPC1XXX_IAP_64 (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: LPC1xxx_64
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=3
  c define: LPC1XXX FLASH_64
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target LPC1XXX_IAP_80 (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: LPC1xxx_80
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=3
  c define: LPC1XXX FLASH_80
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target LPC1XXX_IAP_96 (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: LPC1xxx_96
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=3
  c define: LPC1XXX FLASH_96
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target LPC1XXX_IAP_128 (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: LPC1xxx_128
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=3
  c define: LPC1XXX FLASH_128
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target LPC17XX_IAP_32 (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: LPC_IAP_32
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=3
  c define: LPC17XX FLASH_32
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target LPC17XX_IAP_64 (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: LPC_IAP_64
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=3
  c define: LPC17XX FLASH_64
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target LPC17XX_IAP_128 (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: LPC_IAP_128
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=3
  c define: LPC17XX FLASH_128
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target LPC17XX_IAP_256 (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: LPC_IAP_256
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=3
  c define: LPC17XX FLASH_256
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target LPC17XX_IAP_512 (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: LPC_IAP_512
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=3
  c define: LPC17XX FLASH_512
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target LPC1XXX_IAP_96_32 (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: LPC1xxx_96_32
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=3
  c define: LPC11U6X FLASH_128
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target LPC1XXX_IAP_96_160 (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: LPC1xxx_96_160
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=3
  c define: LPC11U6X FLASH_256
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
