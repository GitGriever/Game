# Keil uVision project EFM32ZG.uvproj, settings and files
target EFM32ZG.FLM (ARM-ADS)
  device: EFM32ZG222F32 Energy Micro
  cpu: IRAM(0x20000000-0x20000FFF) IROM(0-0x7FFF) CLOCK(24000000) CPUTYPE("Cortex-M0+") ESEL ELITTLE
  output: EFM32ZG +hex
  AfterMake: cmd.exe /C copy EFM32ZG.axf ..\EFM32ZG.FLM
  c flags: Optim=4
  c define: EFM32ZG108F4
  c include: ..\..\RV31\LIB\EnergyMicro\emlib\inc
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
  group Program Functions
    ./: FlashPrg.c
  group Device Description
    ./: FlashDev.c
