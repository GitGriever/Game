# Keil uVision project Blinky.uvproj, settings and files
target Simulator (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: Blinky
  c flags: Optim=1
  c define: __ADC_IRQ
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group StartUp
    ./: startup_LPC17xx.s system_LPC17xx.c
  group Source Files
    ./: Retarget.c Serial.c LED.c ADC.c IRQ.c Blinky.c
  group Trace Configuration
    ./: LPC17xx_TPIU.ini
  group Documentation
    ./: Abstract.txt
target SWO Trace (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: as above
  output: Blinky
  c flags: Optim=1
  c define: __ADC_IRQ
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
target TracePort Trace (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: as above
  output: Blinky
  c flags: Optim=1
  c define: __ADC_IRQ
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
target TracePort InstructionTrace (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: as above
  output: Blinky
  c flags: Optim=1
  c define: __ADC_IRQ
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
