# Keil uVision project Memory.uvproj, settings and files
target STM32F207 Flash (ARM-ADS)
  device: STM32F207IG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: Memory
  c flags: Optim=4
  c include: ..\Library
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Startup Code
    ./: startup_stm32f2xx.s system_stm32f2xx.c SVC_Table.s
  group Configuration
    ./: File_Config.c usb_config_HS.c RTX_Conf_CM.c
  group Drivers
    ./: LED.c KBD.c Serial.c GLCD_16bitIF_STM32F2xx.c SDIO_STM32F2xx.c
  group File System
    ./: Retarget.c
    C:/Keil/ARM/RV31/LIB/: FS_CM3.lib
  group USB
    C:/Keil/ARM/RV31/LIB/: USB_CM3.lib
    ./: usbd_STM32F2xx_HS.c usbd_user_msc.c
  group Main Code
    ./: Getline.c SD_File.c Memory.c
  group Documentation
    ./: Abstract.txt
