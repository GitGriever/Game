# Keil uVision project EFM32GG.uvproj, settings and files
target EFM32GG.FLM (ARM-ADS)
  device: EFM32GG990F1024 Energy Micro
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0-0xFFFFF) CLOCK(48000000) CPUTYPE("Cortex-M3")
  output: EFM32GG
  AfterMake: cmd.exe /C copy EFM32GG.axf ..\EFM32GG.FLM
  c flags: Optim=4
  c define: EFM32GG990F1024
  c include: ..\..\RV31\LIB\EnergyMicro\emlib\inc
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
  group Program Functions
    ./: FlashPrg.c FlashOS.h
  group Device Description
    ./: FlashDev.c
