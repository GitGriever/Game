# Keil uVision project Blinky.uvproj, settings and files
target SAM3S Flash (ARM-ADS)
  device: SAM3S4C Atmel
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x400000-0x43FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: Blinky
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x400000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group StartUp
    ./: startup_SAM3S.s system_SAM3S.c
  group Pictures
    ./: Bg_16bpp_b.c Bg_16bpp_l.c Bg_16bpp_r.c Bg_16bpp_t.c ARM_Ani_16bpp.c
  group Source Files
    ./: GLCD_8bitIF_SAM3S.c LED.c IRQ.c Blinky.c
  group Documentation
    ./: Abstract.txt
