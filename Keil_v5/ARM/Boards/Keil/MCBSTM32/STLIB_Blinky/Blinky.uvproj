# Keil uVision project Blinky.uvproj, settings and files
target Simulator (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Blinky
  c flags: Optim=1
  c define: STM32F10X_MD USE_STDPERIPH_DRIVER
  c include: .\; ..\..\..\..\RV31\LIB\ST\STM32F10x_StdPeriph_Driver\inc
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group StartUp
    ./: startup_stm32f10x_md.s system_stm32f10x.c
  group Interrupts
    ./: IRQ.c
  group Retarget
    ./: Retarget.c
  group Source Code
    ./: LCD_4bit.c LED.c Serial.c Setup.c Blinky.c
  group StdPeriph_Driver
    ../../../../RV31/LIB/ST/STM32F10x_StdPeriph_Driver/src/: stm32f10x_adc.c stm32f10x_dma.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c
  group Documentation
    ./: Abstract.txt
target STM32F103 Flash (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: as above
  output: Blinky
  c flags: Optim=4
  c define: STM32F10X_MD USE_STDPERIPH_DRIVER
  c include: .\; ..\..\..\..\RV31\LIB\ST\STM32F10x_StdPeriph_Driver\inc
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target STM32F103 RAM (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: as above
  output: Blinky
  c flags: Optim=1
  c define: STM32F10X_MD USE_STDPERIPH_DRIVER VECT_TAB_SRAM
  c include: .\; ..\..\..\..\RV31\LIB\ST\STM32F10x_StdPeriph_Driver\inc
  memory RVCT4: ROM 0x20000000 size 0x4000
  memory RVCT9: RAM 0x20004000 size 0x1000
target STM32F103 Trace A (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: as above
  output: Blinky
  c flags: Optim=4
  c define: STM32F10X_MD USE_STDPERIPH_DRIVER
  c include: .\; ..\..\..\..\RV31\LIB\ST\STM32F10x_StdPeriph_Driver\inc
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target STM32F103 Trace B (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: as above
  output: Blinky
  c flags: Optim=4
  c define: STM32F10X_MD USE_STDPERIPH_DRIVER
  c include: .\; ..\..\..\..\RV31\LIB\ST\STM32F10x_StdPeriph_Driver\inc
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target STM32F103 Trace C (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: as above
  output: Blinky
  c flags: Optim=4
  c define: STM32F10X_MD USE_STDPERIPH_DRIVER
  c include: .\; ..\..\..\..\RV31\LIB\ST\STM32F10x_StdPeriph_Driver\inc
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
