# Keil uVision project STM32Fx_M25P64.uvproj, settings and files
target STM32F10x_M25P64 (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM32F10x_M25P64
  AfterMake: cmd.exe /C copy Out\STM32F10x_M25P64.axf ..\STM32F10x_M25P64.FLM
  c flags: Optim=4
  c define: STM32F10X_HD USE_STDPERIPH_DRIVER
  c include: ./
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
  group Program Functions
    ./: FlashPrg.c spi_flash.c stm32f10x_spi.c stm32f10x_rcc.c stm32f10x_gpio.c
  group Device Description
    ./: FlashDev.c
