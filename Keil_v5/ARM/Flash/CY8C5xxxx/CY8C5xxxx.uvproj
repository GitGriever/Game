# Keil uVision project CY8C5xxxx.uvproj, settings and files
target CY8C5xxxx Flash (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3") ESEL ELITTLE
  output: CY8C5xxxx
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=3
  c define: CY8C5XXXX_FLASH
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
  group Program Functions
    ./: FlashPrg.c
  group Device Description
    ./: FlashDev.c
target CY8C5xxxx Configuration (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3") ESEL ELITTLE
  output: CY8C5xxxx_CFG
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=3
  c define: CY8C5XXXX_CFG
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target CY8C5xxxx Protection (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3") ESEL ELITTLE
  output: CY8C5xxxx_FP
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=3
  c define: CY8C5XXXX_PROTECT
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target CY8C5xxxx EEPROM (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3") ESEL ELITTLE
  output: CY8C5xxxx_EEPROM
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=3
  c define: CY8C5XXXX_EEPROM
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target CY8C5xxxx CFG NVL (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3") ESEL ELITTLE
  output: CY8C5xxxx_CFG_NVL
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=3
  c define: CY8C5XXXX_CFG_NVL
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target CY8C5xxxx WO NVL (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3") ESEL ELITTLE
  output: CY8C5xxxx_WO_NVL
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=3
  c define: CY8C5XXXX_WO_NVL
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
