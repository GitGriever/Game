# Keil uVision project VirtualCOM.uvproj, settings and files
target MCBSTM32 RTX (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: VirtualCOM
  c flags: Optim=4
  c define: STM32F10X_MD
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group StartUp
    ./: startup_stm32f10x_md.s system_stm32f10x.c SVC_Table.s
  group Configuration
    ./: usb_config.c RTX_Conf_CM.c
  group USB HW Driver
    ./: usbd_STM32F103.c
  group Source
    ./: USBD_Demo.c LCD_4bit.c UART_STM32.c usbd_user_cdc_acm.c
  group Library
    C:/Keil/ARM/RV31/LIB/: USB_CM3.lib
  group Documentation
    ./: Abstract.txt
