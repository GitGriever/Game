# Keil uVision project MKE02Zxxx.uvproj, settings and files
target MKE02Zxxx_P64KB (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: MKE02Zxxx_P64KB
  AfterMake: cmd.exe /C copy ".\Out\%L" "..\@L.FLM"
  c flags: Optim=3
  c define: MKE02Zxxx_P64KB
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
  group Program Functions
    ./: FlashPrg.c
  group Device Description
    ./: FlashDev.c
target MKE02Zxxx_P32KB (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: MKE02Zxxx_P32KB
  AfterMake: cmd.exe /C copy ".\Out\%L" "..\@L.FLM"
  c flags: Optim=3
  c define: MKE02Zxxx_P32KB
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target MKE02Zxxx_P16KB (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: MKE02Zxxx_P16KB
  AfterMake: cmd.exe /C copy ".\Out\%L" "..\@L.FLM"
  c flags: Optim=3
  c define: MKE02Zxxx_P16KB
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target MKE02Zxxx_EE256B (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: MKE02Zxxx_EE256B
  AfterMake: cmd.exe /C copy ".\Out\%L" "..\@L.FLM"
  c flags: Optim=3
  c define: MKE02Zxxx_EE256B EEPROM
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
