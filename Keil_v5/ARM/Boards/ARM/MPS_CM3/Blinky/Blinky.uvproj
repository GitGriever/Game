# Keil uVision project Blinky.uvproj, settings and files
target MPS CM3 Ext RAM (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: Blinky
  c flags: Optim=1
  c define: REMAP
  library: MicroLIB
  memory RVCT1: ROM 0x0 size 0x400000
  memory RVCT6: RAM 0x20000000 size 0x400000
  group Startup Code
    ./: startup_MPS_CM3.s
  group System Code
    ./: system_MPS_CM3.c
  group Core Code
    ./: core_cm3.c
  group Library Code
    C:/Keil/ARM/RV31/LIB/ARM/MPS/: MPS_CM3.LIB
  group Source Code
    ./: Blinky.c
  group Documentation
    ./: Abstract.txt
target MPS CM3 Ext Flash (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: Blinky
  c flags: Optim=1
  library: MicroLIB
  memory RVCT1: ROM 0x0 size 0x4000000
  memory RVCT6: RAM 0x20000000 size 0x400000
