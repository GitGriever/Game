# Keil uVision project Http_demo.uvproj, settings and files
target LM3S9B92 (ARM-ADS)
  device: LM3S9B92 Luminary Micro
  cpu: IRAM(0x20000000-0x20017FFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Http_demo
  c flags: Optim=1
  c define: rvmdk PART_LM3S9B92
  c include: ..\Library; C:/Keil/ARM/RV31/LIB/Luminary
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group HTTP Files
    ./Web/: Web.inp index.htm network.cgi leds.cgi system.cgi tcp.cgi language.cgi buttons.cgi buttons.cgx pg_header.inc pg_footer.inc xml_http.js
  group Source Files
    ./: HTTP_demo.c HTTP_CGI.c
    ./Web/: WEB.C
  group Configuration Files
    ./: Net_Config.c Net_Debug.c RTX_Conf_CM.c startup_rvmdk.S startup_rvmdk_RTX.S
  group Library
    C:/Keil/ARM/RV31/LIB/: TCP_CM3.lib TCPD_CM3.lib
    C:/Keil/ARM/RV31/LIB/Luminary/: driverlib-cm3.lib
    ../Library/: LM3S_EMAC.c
  group Documentation
    ./: Abstract.txt
target LM3S9B92 Debug (ARM-ADS)
  device: LM3S9B92 Luminary Micro
  cpu: as above
  output: Http_demo
  c flags: Optim=4
  c define: rvmdk PART_LM3S9B92
  c include: ..\Library; C:/Keil/ARM/RV31/LIB/Luminary
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x18000
target LM3S9B92 RTX (ARM-ADS)
  device: LM3S9B92 Luminary Micro
  cpu: as above
  output: Http_demo
  c flags: Optim=4
  c define: rvmdk PART_LM3S9B92 RTX_KERNEL
  c include: ..\Library; C:/Keil/ARM/RV31/LIB/Luminary
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x18000
