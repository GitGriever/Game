# Keil uVision project TMPM33x.uvproj, settings and files
target TMPM33x_512 (ARM-ADS)
  device: TMPM330FDFG Toshiba
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x7FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: TMPM33x_512
  AfterMake: cmd.exe /C copy TMPM33x_512.axf ..\TMPM33x_512.FLM
  c flags: Optim=3
  c define: TMPM33X_512
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
  group Program Functions
    ./: FlashPrg.c
  group Device Description
    ./: FlashDev.c
target TMPM33x_256 (ARM-ADS)
  device: TMPM330FDFG Toshiba
  cpu: as above
  output: TMPM33x_256
  AfterMake: cmd.exe /C copy TMPM33x_256.axf ..\TMPM33x_256.FLM
  c flags: Optim=3
  c define: TMPM33X_256
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target TMPM33x_128 (ARM-ADS)
  device: TMPM330FDFG Toshiba
  cpu: as above
  output: TMPM33x_128
  AfterMake: cmd.exe /C copy TMPM33x_128.axf ..\TMPM33x_128.FLM
  c flags: Optim=3
  c define: TMPM33X_128
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
