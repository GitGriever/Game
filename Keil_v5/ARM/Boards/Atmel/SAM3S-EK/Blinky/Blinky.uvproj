# Keil uVision project Blinky.uvproj, settings and files
target SAM3S RAM (ARM-ADS)
  device: SAM3S4C Atmel
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x400000-0x43FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: Blinky
  c flags: Optim=1
  c define: __USE_LCD
  library: MicroLIB
  memory RVCT4: ROM 0x20000000 size 0x4000
  memory RVCT9: RAM 0x20004000 size 0x4000
  group StartUp
    ./: startup_SAM3S.s system_SAM3S.c
  group GPNVM Bits
    ./: SAM3xGPNVM.s
  group Source Files
    ./: GLCD_8bitIF_SAM3S.c Retarget.c Serial.c LED.c ADC.c IRQ.c Blinky.c
  group Documentation
    ./: Abstract.txt
target SAM3S Flash (ARM-ADS)
  device: SAM3S4C Atmel
  cpu: as above
  output: Blinky
  c flags: Optim=1
  c define: __USE_LCD
  library: MicroLIB
  memory RVCT4: ROM 0x400000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
target SAN3S Flash + GPNVM (ARM-ADS)
  device: SAM3S4C Atmel
  cpu: as above
  output: Blinky
  c flags: Optim=1
  c define: __USE_LCD
  library: MicroLIB
  memory RVCT4: ROM 0x400000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
