# Keil uVision project Blinky.uvproj, settings and files
target ULink - Flash (ARM-ADS)
  device: MK70FN1M0xxx12 Freescale Semiconductor
  cpu: IRAM(0x1FFF0000-0x1FFFFFFF) IRAM2(0x20000000-0x2000FFFF) IROM(0x0-0xFFFFF) CLOCK(12000000) CPUTYPE("Cortex-M4")  FPU2 ELITTLE
  output: Blinky
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x10000
  group Startup
    ./: startup_MK70F12.s system_MK70F12.c
  group Source Files
    ./: Blinky.c
  group Documentation
    ./: Abstract.txt
target ULink - RAM (ARM-ADS)
  device: MK70FN1M0xxx12 Freescale Semiconductor
  cpu: as above
  output: Blinky
  c flags: Optim=1
  memory RVCT4: ROM 0x1fff0000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x10000
target ULink- Ext SDRAM (ARM-ADS)
  device: MK70FN1M0xxx12 Freescale Semiconductor
  cpu: as above
  output: Blinky
  c flags: Optim=1
  memory RVCT1: ROM 0x80000000 size 0x100000
  memory RVCT4: ROM 0x1fff0000 size 0x10000
  memory RVCT6: RAM 0x80100000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x10000
target ULinkPro - Flash (ARM-ADS)
  device: MK70FN1M0xxx12 Freescale Semiconductor
  cpu: as above
  output: Blinky
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x10000
target ULinkPro - RAM (ARM-ADS)
  device: MK70FN1M0xxx12 Freescale Semiconductor
  cpu: as above
  output: Blinky
  c flags: Optim=1
  memory RVCT4: ROM 0x1fff0000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x10000
target ULinkPro- Ext SDRAM (ARM-ADS)
  device: MK70FN1M0xxx12 Freescale Semiconductor
  cpu: as above
  output: Blinky
  c flags: Optim=1
  memory RVCT1: ROM 0x80000000 size 0x100000
  memory RVCT4: ROM 0x1fff0000 size 0x10000
  memory RVCT6: RAM 0x80100000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x10000
target PE OSJTAG - Flash (ARM-ADS)
  device: MK70FN1M0xxx12 Freescale Semiconductor
  cpu: as above
  output: Blinky
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x10000
target PE OSJTAG - RAM (ARM-ADS)
  device: MK70FN1M0xxx12 Freescale Semiconductor
  cpu: as above
  output: Blinky
  c flags: Optim=1
  memory RVCT4: ROM 0x1fff0000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x10000
