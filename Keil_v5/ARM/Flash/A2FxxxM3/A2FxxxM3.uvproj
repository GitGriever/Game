# Keil uVision project A2FxxxM3.uvproj, settings and files
target A2FxxxM3 128kB (ARM-ADS)
  device: A2F200M3F Actel
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x00000000-0x0003FFFF) CLOCK(20000000) CPUTYPE("Cortex-M3")
  output: A2FxxxM3_128
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=3
  c define: A2FxxxM3_128
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\Target.lin
  link misc: --diag_suppress 6305
  group Program Functions
    ./: FlashPrg.c
  group Device Description
    ./: FlashDev.c
target A2FxxxM3 256kB (ARM-ADS)
  device: A2F200M3F Actel
  cpu: as above
  output: A2FxxxM3_256
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=3
  c define: A2FxxxM3_256
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\Target.lin
  link misc: --diag_suppress 6305
target A2FxxxM3 512kB (ARM-ADS)
  device: A2F200M3F Actel
  cpu: as above
  output: A2FxxxM3_512
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=3
  c define: A2FxxxM3_512
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\Target.lin
  link misc: --diag_suppress 6305
