# Keil uVision project Blinky.uvproj, settings and files
target LM3S9B92 Flash (ARM-ADS)
  device: LM3S9B92 Luminary Micro
  cpu: IRAM(0x20000000-0x20017FFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Blinky
  c flags: Optim=4
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group Startup Code
    ./: startup_lm3s.s
  group System Code
    ./: system_lm3s9bxx.c
  group Configuration
    ./: RTX_Conf_CM.c lm3s_config.h
  group Source
    ./: Blinky.c
  group Library
    C:/Keil/ARM/RV31/LIB/Luminary/: driverlib-cm3.lib
  group Documentation
    ./: Abstract.txt
