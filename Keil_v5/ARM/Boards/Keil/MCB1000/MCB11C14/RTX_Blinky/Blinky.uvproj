# Keil uVision project Blinky.uvproj, settings and files
target Simulator (ARM-ADS)
  device: LPC11C14/301 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10001FFF) IROM(0-0x7FFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: Blinky
  c flags: Optim=1
  c include: .
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x2000
  group StartUp
    ./: startup_LPC11xx.s system_LPC11xx.c
  group RTX Configuration
    ./: RTX_Conf_CM.c
  group Source Files
    ./: Blinky.c
  group Documentation
    ./: Abstract.txt
target LPC11C14 RAM (ARM-ADS)
  device: LPC11C14/301 NXP (founded by Philips)
  cpu: as above
  output: Blinky
  c flags: Optim=1
  c include: .
  library: MicroLIB
  memory RVCT4: ROM 0x10000000 size 0x1400
  memory RVCT9: RAM 0x10001400 size 0xc00
target LPC11C14 Flash (ARM-ADS)
  device: LPC11C14/301 NXP (founded by Philips)
  cpu: as above
  output: Blinky
  c flags: Optim=1
  c include: .
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x2000
