# Keil uVision project Template.uvproj, settings and files
target MCBSTM32F200 (ARM-ADS)
  device: STM32F207IG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: Template
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c include: C:\Keil\ARM\Segger\emWin\Include
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Startup
    ./: startup_stm32f2xx.s system_stm32f2xx.c
  group RTX Configuration
    ./: RTX_Conf_CM.c
  group LCD Driver
    ./: LCDConf.c LCD_X_16BitIF_STM32F2xx.c
  group GUI Library
    ./: GUIConf.c GUI_X_RTX.c
    C:/Keil/ARM/Segger/emWin/Lib/: GUI_CM3.lib
  group Source Code
    ./: main.c
  group Documentation
    ./: Abstract.txt
target MCBSTM32F200 LCD_LG (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F207IG STMicroelectronics
  cpu: as above
  output: Template
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c include: C:\Keil\ARM\Segger\emWin\Include
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
