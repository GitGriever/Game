# Keil uVision project Measure.uvproj, settings and files
target Simulator (ARM-ADS)
  device: STM32F103VB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Measure
  c flags: Optim=1
  c define: STM32F10X_MD __USART1
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group StartUp
    ./: startup_stm32f10x_md.s system_stm32f10x.c
  group Source
    ./: Measure.c Getline.c Mcommand.c ADC.c LCD.c LED.c Serial.c Retarget.c
  group Documentation
    ./: Abstract.txt
target STM32F103 Flash (ARM-ADS)
  device: STM32F103VB STMicroelectronics
  cpu: as above
  output: Measure
  c flags: Optim=1
  c define: STM32F10X_MD __USE_LCD __USART1
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target STM32F103 RAM (ARM-ADS)
  device: STM32F103VB STMicroelectronics
  cpu: as above
  output: Measure
  c flags: Optim=1
  c define: STM32F10X_MD VECT_TAB_SRAM __USE_LCD __USART1
  library: MicroLIB
  memory RVCT4: ROM 0x20000000 size 0x4000
  memory RVCT9: RAM 0x20004000 size 0x1000
