# Keil uVision project Memory.uvproj, settings and files
target SAM3U4E Flash (ARM-ADS)
  device: SAM3U4E Atmel
  cpu: IRAM(0x20000000-0x20007FFF) IRAM2(0x20080000-0x20083FFF) IROM(0x80000-0x9FFFF) IROM2(0x100000-0x11FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: Memory
  c flags: Optim=4
  memory RVCT4: ROM 0x80000 size 0x20000
  memory RVCT5: ROM 0x100000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x20080000 size 0x4000
  group Startup Code
    ./: startup_SAM3U.s system_SAM3U.c SVC_Table.s
  group Configuration
    ./: File_Config.c usb_config.c RTX_Conf_CM.c
  group Drivers
    ./: LED.c KBD.c Serial.c GLCD_16bitIF_SAM3U.c MCI_SAM3U.c
  group File System
    ./: Retarget.c
    C:/Keil/ARM/RV31/LIB/: FS_CM3.lib
  group USB
    C:/Keil/ARM/RV31/LIB/: USB_CM3.lib
    ./: usbd_SAM3U.c usbd_user_msc.c
  group Main Code
    ./: Getline.c SD_File.c Memory.c
  group Documentation
    ./: Abstract.txt
