# Keil uVision project SD_File.uvproj, settings and files
target EFM32G290F128 Flash (ARM-ADS)
  device: EFM32G290F128 Energy Micro
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x1FFFF) CLOCK(32000000) CPUTYPE("Cortex-M3")
  output: SD_File
  c flags: Optim=1
  c define: DEBUG_EFM
  c misc: --c99
  c include: ..\..\..\bsp;..\..\..\..\..\..\RV31\LIB\EnergyMicro\emlib\inc
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group StartUp
    ./: startup_efm32g.s system_efm32g.c
  group BSP
    ../../../bsp/: dvk.c dvk_ebi.c dvk_spi.c dvk_boardcontrol.c trace.c
  group EMLib
    ../../../../../../RV31/LIB/EnergyMicro/emlib/src/: em_acmp.c em_adc.c em_aes.c em_assert.c em_burtc.c em_cmu.c em_dac.c em_dbg.c em_dma.c em_ebi.c em_emu.c em_gpio.c em_i2c.c em_int.c em_lcd.c em_lesense.c em_letimer.c em_leuart.c em_mpu.c em_msc.c em_opamp.c em_pcnt.c em_prs.c em_rmu.c em_rtc.c em_system.c em_timer.c em_usart.c em_vcmp.c em_wdog.c
  group Configuration
    ./: File_Config.c
  group Source Files
    ./: SPI_EFM32_Gxxx.c Serial.c Getline.c SD_File.c
  group Retarget
    ./: Retarget.c
  group Library
    ../../../../../../RV31/LIB/: FS_CM3.lib
  group Documentation
    ./: Abstract.txt
target EFM32G890F128 Flash (ARM-ADS)
  device: EFM32G890F128 Energy Micro
  cpu: as above
  output: SD_File
  c flags: Optim=1
  c define: DEBUG_EFM
  c misc: --c99
  c include: as above
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
