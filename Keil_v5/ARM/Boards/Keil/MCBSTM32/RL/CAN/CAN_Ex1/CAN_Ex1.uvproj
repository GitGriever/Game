# Keil uVision project CAN_Ex1.uvproj, settings and files
target Simulator (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: CAN_EX1
  c flags: Optim=1
  c define: STM32F10X_MD
  c include: ./
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group StartUp
    ./: startup_stm32f10x_md.s system_stm32f10x.c
  group RTX Configuration
    ./: RTX_Conf_CM.c
  group CAN Core
    ./: CAN_Cfg.h
    C:/Keil/ARM/RL/CAN/SRC/: RTX_CAN.c
  group CAN Driver
    ./: CAN_STM32F103.c
  group Source
    ./: CAN_Ex1.c LCD_4bit.c
  group Documentation
    ./: Abstract.txt
target STM32 Flash (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: as above
  output: CAN_Ex1
  c flags: Optim=1
  c define: STM32F10X_MD
  c include: ./
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
