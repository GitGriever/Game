# Keil uVision project Memory.uvproj, settings and files
target MCBSTM32C RTX (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: Memory
  c flags: Optim=4
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Startup Code
    ./: system_stm32f10x_cl.c startup_stm32f10x_cl.s SVC_Table.s
  group Configuration
    ./: usb_config.c RTX_Conf_CM.c
  group USB HW Driver
    ./: usbd_STM32F10x_cl.c
  group Source
    ./: USBD_Demo.c DiskImg.c usbd_user_msc.c GLCD_SPI_STM32.c
  group Library
    C:/Keil/ARM/RV31/LIB/: USB_CM3.lib
  group Documentation
    ./: Abstract.txt
