# Keil uVision project MKMXX.uvproj, settings and files
target MKMP64_1KB (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: MKMP64_1KB
  AfterMake: cmd.exe /C copy ".\Output\%L" "..\@L.FLM"
  c flags: Optim=3
  c define: MKMP64_1KB
  c misc: --diag_suppress=1
  c include: .\C90TFS\drvsrc\include;..\..\INC\Freescale\Kinetis
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
  group Program Functions
    ./: FlashPrg.c
  group Device Description
    ./: FlashDev.c
  group Flash Library
    ./C90TFS/drvsrc/source/: DEFlashPartition.c DFlashGetProtection.c DFlashSetProtection.c EEEWrite.c EERAMGetProtection.c EERAMSetProtection.c FlashCheckSum.c FlashCommandSequence.c FlashEraseAllBlock.c FlashEraseBlock.c FlashEraseResume.c FlashEraseSector.c FlashEraseSuspend.c FlashGetInterruptEnable.c FlashGetSecurityState.c FlashInit.c FlashProgramCheck.c FlashProgramLongword.c FlashProgramOnce.c FlashProgramSection.c FlashReadOnce.c FlashReadResource.c FlashSecurityBypass.c FlashSetInterruptEnable.c FlashVerifyAllBlock.c FlashVerifyBlock.c FlashVerifySection.c PFlashGetProtection.c PFlashSetProtection.c SetEEEEnable.c FlashProgramPhrase.c FlashEraseSector_Keil.c FlashProgramLongword_Keil.c
target MKMP128_1KB (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: MKMP128_1KB
  AfterMake: cmd.exe /C copy ".\Output\%L" "..\@L.FLM"
  c flags: Optim=3
  c define: MKMP128_1KB
  c misc: --diag_suppress=1
  c include: .\C90TFS\drvsrc\include;..\..\INC\Freescale\Kinetis
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target MKMPIFR (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: MKMPIFR
  AfterMake: cmd.exe /C copy ".\Output\%L" "..\@L.FLM"
  c flags: Optim=3
  c define: MKMPIFR
  c misc: --diag_suppress=1
  c include: .\C90TFS\drvsrc\include;..\..\INC\Freescale\Kinetis
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
