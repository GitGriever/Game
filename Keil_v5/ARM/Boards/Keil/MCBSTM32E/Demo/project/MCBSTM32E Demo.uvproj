# Keil uVision project MCBSTM32E Demo.uvproj, settings and files
target MCBSTM32E (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Demo
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: STM32F10X_HD USE_STDPERIPH_DRIVER
  c include: ..\include;..\..\..\..\..\RV31\LIB\ST\STM32F10x_StdPeriph_Driver\inc;..\..\..\..\..\RV31\LIB\ST\STM32_USB-FS-Device_Driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group StartUp
    ./: startup_stm32f10x_hd.s system_stm32f10x.c
  group Source
    ../source/: stm32f10x_it.c main.c menu.c calendar.c lcd.c hw_config.c usb_desc.c usb_istr.c usb_prop.c usb_pwr.c dac_codec.c waveplayer.c fsmc_nor.c lowpower.c mass_storage.c fsmc_nand.c mass_mal.c memory.c nand_if.c scsi_data.c sdcard.c usb_bot.c usb_endp.c usb_scsi.c smartcard.c spi_flash.c tsensor.c
  group StdPeriph_Driver
    ../../../../../RV31/LIB/ST/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_usart.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_dac.c
  group USB-FS-Device_Driver
    ../../../../../RV31/LIB/ST/STM32_USB-FS-Device_Driver/src/: usb_regs.c usb_core.c usb_init.c usb_int.c usb_mem.c
  group Documentation
    ./: Abstract.txt
target MCBSTM32E Download MM (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: as above
  output: STM32E_MM.elf
  c flags: OneElfS=1 wLevel=2
  c define: STM32F10X_HD USE_STDPERIPH_DRIVER
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
