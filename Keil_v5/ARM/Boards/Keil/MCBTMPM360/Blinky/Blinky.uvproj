# Keil uVision project Blinky.uvproj, settings and files
target TMPM36x Flash (ARM-ADS)
  device: TMPM364F10FG Toshiba
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0-0x0FFFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Blinky
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Startup Code
    ./: startup_TMPM364.s
  group System Code
    ./: system_TMPM364.c
  group Source Code
    ./: ADC.c Blinky.c BTN.c LED.c
  group Documentation
    ./: Abstract.txt
target TMPM36x RAM (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: TMPM364F10FG Toshiba
  cpu: as above
  output: Blinky
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x20000000 size 0x8000
  memory RVCT9: RAM 0x20008000 size 0x8000
