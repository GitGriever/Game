# Keil uVision project CAN_Ex1.uvproj, settings and files
target STM32F407 Flash (ARM-ADS)
  device: STM32F407IG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: CAN_Ex1
  c flags: Optim=4
  c define: __STM_EVAL
  c include: ./
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group StartUp
    ./: startup_stm32f40_41xxx.s system_stm32f4xx.c
  group Configuration
    ./: RTX_Conf_CM.c
  group CAN Core
    ./: CAN_Cfg.h
    C:/Keil/ARM/RL/CAN/SRC/: RTX_CAN.c
  group CAN Driver
    ./: CAN_STM32F40x.c
  group Source
    ./: CAN_Ex1.c
  group Driver
    ./: ADC.c GLCD_16bitIF_STM32F4xx.c
  group Documentation
    ./: Abstract.txt
