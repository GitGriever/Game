# Keil uVision project Blinky.uvproj, settings and files
target SWO Trace (ARM-ADS)
  device: TMPM364F10FG Toshiba
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0-0x0FFFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Blinky
  c flags: Optim=1
  c define: __DBG_ITM
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group System Files
    ./: startup_TMPM364.s system_TMPM364.c
  group Source Files
    ./: Blinky.c Retarget.c Serial.c IRQ.c
  group Trace Configuration
    ./: TMPM36x_TP.ini TMPM36x_SWO.ini
  group Documentation
    ./: Abstract.txt
target TracePort Trace (ARM-ADS)
  device: TMPM364F10FG Toshiba
  cpu: as above
  output: Blinky
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x10000
target TracePort InstructionTrace (ARM-ADS)
  device: TMPM364F10FG Toshiba
  cpu: as above
  output: Blinky
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x10000
target RAM (ARM-ADS)
  device: TMPM364F10FG Toshiba
  cpu: as above
  output: Blinky
  c flags: Optim=1
  c define: __DBG_ITM
  library: MicroLIB
  memory RVCT4: ROM 0x20000000 size 0x8000
  memory RVCT9: RAM 0x20008000 size 0x8000
