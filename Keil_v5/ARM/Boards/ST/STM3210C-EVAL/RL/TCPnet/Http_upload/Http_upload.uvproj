# Keil uVision project Http_upload.uvproj, settings and files
target STM3210C (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: Http_upload
  c flags: Optim=4
  c define: STM32F10X_CL
  c include: ..\Library
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group HTTP Files
    ./Web/: Web.inp index.htm upload.cgi dir.cgi format.cgi pg_footer.inc pg_header.inc
  group Source Files
    ./: HTTP_upload.c HTTP_CGI.c
    ./Web/: WEB.C
  group Configuration Files
    ./: Net_Config.c File_Config.c HTTP_uif.c Retarget.c startup_stm32f10x_cl.s
  group Library
    C:/Keil/ARM/RV31/LIB/: TCP_CM3.lib FS_CM3.lib
    ../Library/: ETH_STM32x.c GLCD.c system_stm32f10x.c
    ./: SPI_STM32F107.c
  group Documentation
    ./: Abstract.txt
