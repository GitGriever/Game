# Keil uVision project SD_File.uvproj, settings and files
target MCBTMPM395 (ARM-ADS)
  device: TMPM395FWAXBG Toshiba
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0-0x1FFFF) CLOCK(20000000) CPUTYPE("Cortex-M3")
  output: SD_File
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group StartUp
    ./: startup_TMPM395.s system_TMPM395.c
  group Configuration
    ./: File_Config.c
  group Retarget
    ./: Retarget.c
  group Source
    ./: Getline.c Serial.c SD_File.c SPI_TMPM395.c
  group Library
    C:/Keil/ARM/RV31/LIB/: FS_CM3.lib
  group Documentation
    ./: Abstract.txt
