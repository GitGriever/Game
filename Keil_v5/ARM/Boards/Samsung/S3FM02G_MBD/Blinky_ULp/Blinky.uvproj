# Keil uVision project Blinky.uvproj, settings and files
target TracePort InstructionTrace (ARM-ADS)
  device: S3FM02G Samsung
  cpu: IRAM(0x20000000-0x20005FFF) IROM(0-0x5FFFF) IROM2(0x80000000-0x80003FFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Blinky
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x60000
  memory RVCT5: ROM 0x80000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x6000
  group System File
    ./: startup_s3fm02g.s system_S3FM02G.c
  group Source File
    ./: main.c
  group Documentation
    ./: Abstract.txt
