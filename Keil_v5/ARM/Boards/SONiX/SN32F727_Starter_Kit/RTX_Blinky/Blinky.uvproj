# Keil uVision project Blinky.uvproj, settings and files
target SN32F717 Flash (ARM-ADS)
  device: SN32F727 SONiX
  cpu: IRAM(0x20000000-0x200007FF) IROM(0x0-0x1FFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: Blinky
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x2000
  memory RVCT9: RAM 0x20000000 size 0x800
  group StartUp
    ./: startup_SN32F720.s system_SN32F720.c
  group RTX Configuration
    ./: RTX_Conf_CM.c
  group Source Files
    ./: LED.c Blinky.c
  group Documentation
    ./: Abstract.txt
