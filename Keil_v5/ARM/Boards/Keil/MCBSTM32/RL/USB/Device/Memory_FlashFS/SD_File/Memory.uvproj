# Keil uVision project Memory.uvproj, settings and files
target MCBSTM32 (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Memory
  c flags: Optim=4
  c define: STM32F10X_MD
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group StartUp
    ./: startup_stm32f10x_md.s system_stm32f10x.c
  group Configuration
    ./: usb_config.c File_Config.c
  group HW Drivers
    ./: usbd_STM32F103.c SPI_STM32F103.c Serial.c LCD_4bit.c
  group File System
    ./: Retarget.c
    C:/Keil/ARM/RV31/LIB/: FS_CM3.lib
  group USB
    ./: usbd_user_msc.c
    C:/Keil/ARM/RV31/LIB/: USB_CM3.lib
  group Main Code
    ./: Getline.c SD_File.c Memory.c
  group Documentation
    ./: Abstract.txt
