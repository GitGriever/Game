# Keil uVision project SD_File.uvproj, settings and files
target MCBSTM32E (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: SD_File
  c flags: Optim=1
  c define: STM32F10X_HD
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group StartUp
    ./: startup_stm32f10x_hd.s system_stm32f10x.c
  group Source Files
    ./: SD_File.c Getline.c GLCD_16bitIF_STM32.c
  group Configuration Files
    ./: File_Config.c SDIO_STM32F103.c
  group Com Port
    ./: Serial.c Retarget.c
  group Library
    C:/Keil/ARM/RV31/LIB/: FS_CM3.lib
  group Documentation
    ./: Abstract.txt
