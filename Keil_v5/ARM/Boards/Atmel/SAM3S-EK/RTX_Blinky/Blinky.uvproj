# Keil uVision project Blinky.uvproj, settings and files
target SAM3S RAM (ARM-ADS)
  device: SAM3S4C Atmel
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x400000-0x43FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: Blinky
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x20000000 size 0x8000
  memory RVCT9: RAM 0x20008000 size 0x4000
  group StartUp
    ./: startup_SAM3S.s system_SAM3S.c
  group RTX Configuration
    ./: RTX_Conf_CM.c
  group Source Files
    ./: Blinky.c LED.c GLCD_8bitIF_SAM3S.c
  group Documentation
    ./: Abstract.txt
target SAM3S Flash (ARM-ADS)
  device: SAM3S4C Atmel
  cpu: as above
  output: Blinky
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x400000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
