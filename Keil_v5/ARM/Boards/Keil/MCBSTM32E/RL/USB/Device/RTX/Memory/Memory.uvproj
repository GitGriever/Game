# Keil uVision project Memory.uvproj, settings and files
target MCBSTM32E RTX (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Memory
  c flags: Optim=4
  c define: STM32F10X_HD __USE_LCD
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Startup Code
    ./: startup_stm32f10x_hd.s system_stm32f10x.c SVC_Table.s
  group Configuration
    ./: RTX_Conf_CM.c usb_config.c
  group USB HW Driver
    ./: usbd_STM32F103.c
  group Source
    ./: USBD_Demo.c DiskImg.c usbd_user_msc.c GLCD_16bitIF_STM32.c
  group Library
    C:/Keil/ARM/RV31/LIB/: USB_CM3.lib
  group Documentation
    ./: Abstract.txt
