# Keil uVision project SD_File.uvproj, settings and files
target XMC4500 Flash ITM (ARM-ADS)
  device: XMC4500-1024 Infineon
  cpu: IRAM(0x20000000-0x2000FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x0C000000-0x0C0FFFFF) IROM2(0x08000000-0x080FFFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") FPU2
  output: SD_File
  c flags: Optim=4
  memory RVCT4: ROM 0xc000000 size 0x100000
  memory RVCT5: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source Files
    ./: SD_File.c Getline.c
  group Configuration Files
    ./: startup_XMC4500.s system_XMC4500.c File_Config.c SDMMC_XMC4500.c
  group Com Port
    ./: Serial_XMC4500_ITM.c Retarget.c
  group Library
    C:/Keil/ARM/RV31/LIB/: FS_CM3.lib
  group Documentation
    ./: Abstract.txt
