# Keil uVision project HID.uvproj, settings and files
target MK20D72M RTX (ARM-ADS)
  device: MK20DX128xxx7 Freescale Semiconductor
  cpu: IRAM(0x1FFFC000-0x1FFFFFFF) IRAM2(0x20000000-0x20003FFF) IROM(0x0-0x1FFFF) IROM2(0x10000000-0x10007FFF) CLOCK(12000000) CPUTYPE("Cortex-M4") ELITTLE
  output: HID
  c flags: Optim=4
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT5: ROM 0x10000000 size 0x8000
  memory RVCT9: RAM 0x1fffc000 size 0x4000
  memory RVCT10: RAM 0x20000000 size 0x4000
  group Startup Code
    ./: startup_MK20D7.s system_MK20D7.c SVC_Table.s
  group Configuration
    ./: usb_config.c RTX_Config.c
  group USB HW Driver
    ./: usbd_MK20D7.c
  group Source
    ./: USBD_Demo.c usbd_user_hid.c LED.c KBD.c
  group Library
    C:/Keil/ARM/RV31/LIB/: USB_CM3.lib
  group Documentation
    ./: Abstract.txt
