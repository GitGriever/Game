# Keil uVision project blinky.uvproj, settings and files
target blinky (ARM-ADS)
  device: LM3S3748 Luminary Micro
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0-0x1FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: blinky
  AfterMake: fromelf --bin --output .\obj\blinky.bin .\obj\blinky.axf
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: rvmdk PART_LM3S3748
  c include: ..;..\..\..;
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x10000
  link misc: --entry Reset_Handler
  group Source Code
    ./: blinky.c startup.S
  group Documentation
    ./: readme.txt
