# Keil uVision project Blinky.uvproj, settings and files
target STM32F051 Flash (ARM-ADS)
  device: STM32F051R8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: Blinky
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group StartUp
    ./: startup_stm32f051.s system_stm32f0xx.c
  group Source Files
    ./: LED.c Blinky.c
  group Documentation
    ./: Abstract.txt
  group RTX Configuration
    ./: RTX_Conf_CM.c
target STM32F051 RAM (ARM-ADS)
  device: STM32F051R8 STMicroelectronics
  cpu: as above
  output: Blinky
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x20000000 size 0x1400
  memory RVCT9: RAM 0x20001400 size 0xc00
