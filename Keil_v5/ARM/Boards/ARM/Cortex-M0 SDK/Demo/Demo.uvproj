# Keil uVision project Demo.uvproj, settings and files
target Cortex-M0 SDK - Simulator (ARM-ADS)
  device: Cortex-M0 SDK ARM
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x00000000-0x0000FFFF) CLOCK(100000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: Demo
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Startup Files
    ./: startup_CMSDK_CM0.s system_CMSDK.c
  group Source Files
    ./: Demo.c Retarget.c Serial.c Timer.c
  group Documentation
    ./: Abstract.txt
