# Keil uVision project CAN_Ex1.uvproj, settings and files
target LPC4357 Flash (ARM-ADS)
  device: LPC4350 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x1001FFFF) IRAM2(0x20000000-0x2000FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") FPU2
  output: CAN_Ex1
  AfterMake: $K\ARM\BIN\ElfDwT.exe !L BASEADDRESS(0x1A000000)
  c flags: Optim=4
  c include: .\
  library: MicroLIB
  memory RVCT4: ROM 0x1a000000 size 0x80000
  memory RVCT5: ROM 0x1b000000 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x10000
  group Startup Code
    ./: startup_LPC43xx.s system_LPC43xx.c
  group Configuration
    ./: RTX_Conf_CM.c
  group CAN Core
    ./: CAN_Cfg.h
    C:/Keil/ARM/RL/CAN/SRC/: RTX_CAN.c
  group CAN Driver
    ./: CAN_LPC43xx.c
  group Source
    ./: CAN_Ex1.c ADC_LPC43xx.c LED_LPC43xx.c GLCD_LPC43xx.c
  group Documentation
    ./: Abstract.txt
target LPC4350 Ext. Flash (ARM-ADS)
  device: LPC4350 NXP (founded by Philips)
  cpu: as above
  output: CAN_Ex1
  c flags: Optim=4
  c include: .\
  library: MicroLIB
  memory RVCT1: ROM 0x1c000000 size 0x1000000
  memory RVCT9: RAM 0x10000000 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x10000
target LPC4350 RAM (ARM-ADS)
  device: LPC4350 NXP (founded by Philips)
  cpu: as above
  output: CAN_Ex1
  c flags: Optim=4
  c include: .\
  library: MicroLIB
  memory RVCT4: ROM 0x10000000 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x10000
