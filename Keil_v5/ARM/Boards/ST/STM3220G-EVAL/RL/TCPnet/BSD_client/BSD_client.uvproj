# Keil uVision project BSD_client.uvproj, settings and files
target STM3220G-EVAL (ARM-ADS)
  device: STM32F207IG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: BSD_client
  c flags: Optim=4
  c define: __STM_EVAL
  c include: ..\Library
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Source Files
    ./: BSD_client.c
  group Configuration Files
    ./: Net_Config.c Net_Debug.c RTX_Config.c startup_stm32f2xx.s
  group Library
    C:/Keil/ARM/RV31/LIB/: TCP_CM3.lib TCPD_CM3.lib
    ../Library/: GLCD_16bitIF_STM32F2xx.c system_stm32f2xx.c ETH_STM32F2xx.c
  group Documentation
    ./: Abstract.txt
target STM3220G-EVAL Debug (ARM-ADS)
  device: STM32F207IG STMicroelectronics
  cpu: as above
  output: BSD_client
  c flags: Optim=4
  c define: __STM_EVAL
  c include: ..\Library
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
