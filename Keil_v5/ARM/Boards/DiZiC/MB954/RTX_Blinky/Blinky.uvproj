# Keil uVision project Blinky.uvproj, settings and files
target STM32W108 RAM (ARM-ADS)
  device: STM32W108CC STMicroelectronics
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0x8000000-0x803FFFF) CLOCK(24000000) CPUTYPE("Cortex-M3")
  output: Blinky
  c flags: Optim=1
  c define: STM32W108CC
  library: MicroLIB
  memory RVCT4: ROM 0x20000000 size 0x2000
  memory RVCT9: RAM 0x20002000 size 0x2000
  group StartUp
    ./: startup_stm32w108xx.s system_stm32w108xx.c
  group RTX Configuration
    ./: RTX_Conf_CM.c
  group Source Files
    ./: LED.c Blinky.c
  group Documentation
    ./: Abstract.txt
target STM32W108 Flash (ARM-ADS)
  device: STM32W108CC STMicroelectronics
  cpu: as above
  output: Blinky
  c flags: Optim=1
  c define: STM32W108CC
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x4000
