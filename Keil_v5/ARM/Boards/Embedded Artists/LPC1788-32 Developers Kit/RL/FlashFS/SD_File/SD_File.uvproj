# Keil uVision project SD_File.uvproj, settings and files
target LPC1788 Flash (ARM-ADS)
  device: LPC1788 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x1000FFFF) IRAM2(0x20000000-0x20007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: SD_File
  c flags: Optim=4
  asm define: NO_CRP
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x8000
  group Source Files
    ./: SD_File.c Getline.c
  group Configuration Files
    ./: startup_LPC177x_8x.s system_LPC177x_8x.c File_Config.c MCI_LPC177x_8x.c
  group Com Port
    ./: Serial.c Retarget.c
  group Library
    C:/Keil/ARM/RV31/LIB/: FS_CM3.lib
  group Documentation
    ./: Abstract.txt
target LPC1788 Flash ITM (ARM-ADS)
  device: LPC1788 NXP (founded by Philips)
  cpu: as above
  output: SD_File
  c flags: Optim=4
  asm define: NO_CRP
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x8000
