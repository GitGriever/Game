# Keil uVision project Blinky.uvproj, settings and files
target LPC1549 Flash (ARM-ADS)
  device: LPC1549 NXP (founded by Philips)
  cpu: IRAM(0x02000000-0x02008FFF) IROM(0x0-0x3FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: Blinky
  c flags: Optim=1
  c define: __ADC_IRQ __USE_LCD
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x2000000 size 0x9000
  group StartUp
    ./: startup_LPC15xx.s system_LPC15xx.c
  group Source Files
    ./: Retarget.c Serial.c GLCD_SPI_LPC1500.c LED.c ADC.c JOY.c IRQ.c Blinky.c
  group Documentation
    ./: Abstract.txt
target LPC1549 RAM (ARM-ADS)
  device: LPC1549 NXP (founded by Philips)
  cpu: as above
  output: Blinky
  c flags: Optim=1
  c define: __ADC_IRQ __USE_LCD
  library: MicroLIB
  memory RVCT4: ROM 0x2000000 size 0x5000
  memory RVCT9: RAM 0x2005000 size 0x2000
target LPC1549 SWO (ARM-ADS)
  device: LPC1549 NXP (founded by Philips)
  cpu: as above
  output: Blinky
  c flags: Optim=1
  c define: __ADC_IRQ __USE_LCD
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x2000000 size 0x9000
