# Keil uVision project LM3S_128.uvproj, settings and files
target LM3S_128 (ARM-ADS)
  device: LM3S3768 Luminary Micro
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0-0x1FFFF) CLOCK(4190000) CPUTYPE("Cortex-M3")
  output: LM3S_128
  AfterMake: cmd.exe /C copy Out\LM3S_128.axf ..\LM3S_128.FLM
  c flags: Optim=3
  c include: ..\..\RV31\LIB\Luminary
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
  group Program Functions
    ./: FlashPrg.c
  group Device Description
    ./: FlashDev.c
