# Keil uVision project LM3S_8.uvproj, settings and files
target LM3S_8 (ARM-ADS)
  device: LM3S101 Luminary Micro
  cpu: IRAM(0x20000000-0x200007FF) IROM(0-0x1FFF) CLOCK(20000000) CPUTYPE("Cortex-M3")
  output: LM3S_8
  AfterMake: cmd.exe /C copy LM3S_8.axf ..\LM3S_8.FLM
  c flags: Optim=3
  c include: ..\..\RV31\LIB\Luminary
  memory RVCT4: ROM 0x0 size 0x2000
  memory RVCT9: RAM 0x20000000 size 0x800
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
  group Program Functions
    ./: FlashPrg.c
  group Device Description
    ./: FlashDev.c
