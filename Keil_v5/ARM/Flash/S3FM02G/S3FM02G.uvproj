# Keil uVision project S3FM02G.uvproj, settings and files
target S3FM02G_PFLASH (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3") ESEL ELITTLE
  output: S3FM02G
  AfterMake: cmd.exe /C copy Output\S3FM02G.axf ..\S3FM02G_PFLASH.FLM
  c flags: Optim=3
  c define: S3FM02G_PFLASH
  c include: .\include
  asm define: S3FM02G_DATAFLS
  memory RVCT4: ROM 0x0 size 0x60000
  memory RVCT9: RAM 0x20000000 size 0x6000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
  group Program Functions
    ./: FlashPrg.c
  group Device Description
    ./: FlashDev.c
target S3FM02G_DFLASH (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3") ESEL ELITTLE
  output: S3FM02G
  AfterMake: cmd.exe /C copy Output\S3FM02G.axf ..\S3FM02G_DFLASH.FLM
  c flags: Optim=3
  c define: S3FM02G_DFLASH
  c include: .\include
  asm define: S3FM02G_DATAFLS
  memory RVCT4: ROM 0x0 size 0x60000
  memory RVCT9: RAM 0x20000000 size 0x6000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target S3FM02G_SOPT (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3") ESEL ELITTLE
  output: S3FM02G
  AfterMake: cmd.exe /C copy Output\S3FM02G.axf ..\S3FM02G_SOPT.FLM
  c flags: Optim=3
  c define: S3FM02G_SOPT
  c include: .\include
  asm define: S3FM02G_SOPT
  memory RVCT4: ROM 0x0 size 0x60000
  memory RVCT9: RAM 0x20000000 size 0x6000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
