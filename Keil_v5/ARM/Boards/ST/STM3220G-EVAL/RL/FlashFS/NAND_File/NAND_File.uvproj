# Keil uVision project NAND_File.uvproj, settings and files
target STM3220F - EVAL (ARM-ADS)
  device: STM32F207IG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: NAND_File
  c flags: Optim=4
  c define: STM3220F __STM_EVAL
  c include: C:\Keil\ARM\INC
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Startup Code
    ./: startup_stm32f2xx.s system_stm32f2xx.c
  group Configuration
    ./: File_Config.c
  group Retarget
    ./: Retarget.c
  group Source
    ./: Getline.c Serial.c GLCD_16bitIF_STM32F2xx.c NAND_STM32F2xx.c NAND_File.c
  group Library
    C:/Keil/ARM/RV31/LIB/: FS_CM3.lib
  group Documentation
    ./: Abstract.txt
