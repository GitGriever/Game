# Keil uVision project Blinky.uvproj, settings and files
target MB9AFA32N RAM (ARM-ADS)
  device: MB9AFA32N Fujitsu Semiconductor
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0x00000000-0x0001FFFF) CLOCK(4000000) CPUTYPE("Cortex-M3")
  output: Blinky
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x20000000 size 0x2000
  memory RVCT9: RAM 0x20002000 size 0x2000
  group StartUp
    ./: startup_mb9afa3x.s system_mb9afa3x.c
  group RTX Configuration
    ./: RTX_Conf_CM.c
  group Source Files
    ./: LED.c Blinky.c
  group Documentation
    ./: Abstract.txt
target MB9AFA32N Flash (ARM-ADS)
  device: MB9AFA32N Fujitsu Semiconductor
  cpu: as above
  output: Blinky
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
