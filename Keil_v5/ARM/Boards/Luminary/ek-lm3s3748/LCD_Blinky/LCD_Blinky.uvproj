# Keil uVision project LCD_Blinky.uvproj, settings and files
target LM3S3748 Flash (ARM-ADS)
  device: LM3S3748 Luminary Micro
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0-0x1FFFF) CLOCK(4190000) CPUTYPE("Cortex-M3")
  output: LCD_Blinky
  c flags: Optim=1
  c define: rvmdk PART_LM3S3748 TARGET_IS_DUSTDEVIL_RA0
  c include: C:/Keil/ARM/RV31/LIB/Luminary
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Startup Code
    ./: startup_rvmdk.S
  group Source Code
    ./: Blinky.c
  group Library
    ../: formike128x128x16.c
    ../../../../RV31/LIB/Luminary/: driverlib-cm3.lib grlib-cm3.lib
  group Documentation
    ./: Abstract.txt
