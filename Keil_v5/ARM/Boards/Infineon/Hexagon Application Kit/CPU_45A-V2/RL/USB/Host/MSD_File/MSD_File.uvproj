# Keil uVision project MSD_File.uvproj, settings and files
target XMC4500 Flash ITM (ARM-ADS)
  device: XMC4500-1024 Infineon
  cpu: IRAM(0x20000000-0x2000FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x0C000000-0x0C0FFFFF) IROM2(0x08000000-0x080FFFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") FPU2
  output: MSD_File
  c flags: Optim=4
  memory RVCT4: ROM 0xc000000 size 0x100000
  memory RVCT5: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Startup
    ./: startup_XMC4500.s System_XMC4500.c
  group Configuration
    ./: File_Config.c usb_config.c
  group Retarget
    ./: Retarget.c
  group Application
    ./: MSD_File.c Getline.c Serial_XMC4500_ITM.c fs_usbh_msc.c usbh_xmc4500.c
  group Library
    C:/Keil/ARM/RV31/LIB/: FS_CM3.lib USB_CM3.lib
  group Documentation
    ./: Abstract.txt
