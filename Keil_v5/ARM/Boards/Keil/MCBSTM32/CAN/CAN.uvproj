# Keil uVision project CAN.uvproj, settings and files
target Simulator (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: CanDemo
  c flags: Optim=1
  c define: STM32F10X_MD
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group StartUp
    ./: startup_stm32f10x_md.s system_stm32f10x.c
  group Source Files
    ./: LCD_4bit.c ADC.c CAN.c CanDemo.c
  group Documentation
    ./: Abstract.txt
target STM32F103 Flash (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: as above
  output: CanDemo
  c flags: Optim=1
  c define: STM32F10X_MD __USE_LCD
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target STM32F103 RAM (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: as above
  output: CanDemo
  c flags: Optim=1
  c define: STM32F10X_MD VECT_TAB_SRAM __USE_LCD
  library: MicroLIB
  memory RVCT4: ROM 0x20000000 size 0x2800
  memory RVCT9: RAM 0x20002800 size 0x2800
