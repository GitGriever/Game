# Keil uVision project Memory.uvproj, settings and files
target TMPM369 (ARM-ADS)
  device: TMPM369FDFG Toshiba
  cpu: IRAM(0x20000000-0x200007FF) IRAM2(0x20000800-0x2001FFFF) IROM(0-0x07FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Memory
  c flags: Optim=4
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x800
  memory RVCT10: RAM 0x20000800 size 0x1f800
  group Startup Code
    ./: SVC_Table.s system_TMPM369.c startup_TMPM369.s
  group Configuration
    ./: usb_config.c RTX_Conf_CM.c
  group USB HW Driver
    ./: usbd_tmpm36x.c
  group Source
    ./: USBD_Demo.c usbd_user_msc.c DiskImg.c
  group Library
    C:/Keil/ARM/RV31/LIB/: USB_CM3.lib
  group Documentation
    ./: Abstract.txt
