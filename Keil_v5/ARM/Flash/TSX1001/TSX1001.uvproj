# Keil uVision project TSX1001.uvproj, settings and files
target TSX1001_32 (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: TSX1001_32
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=3
  c define: FLASH_MEMORY TSX1001_32
  library: MicroLIB
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
  group Program Functions
    ./: FlashPrg.c
  group Device Description
    ./: FlashDev.c
