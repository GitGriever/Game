# Keil uVision project HID.uvproj, settings and files
target SAM3S Flash (ARM-ADS)
  device: SAM3S4C Atmel
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x400000-0x43FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: HID
  c flags: Optim=4
  library: MicroLIB
  memory RVCT4: ROM 0x400000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group StartUp
    ./: startup_SAM3S.s system_SAM3S.c
  group Source Files
    ./: usbhw_SAM3S.c usbcfg.h usbcore.c usbdesc.c usbuser.c hiduser.c demo.c
  group Documentation
    ./: Abstract.txt
