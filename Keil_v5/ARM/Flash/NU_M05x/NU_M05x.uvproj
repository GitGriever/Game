# Keil uVision project NU_M05x.uvproj, settings and files
target M05x_8 APROM (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: NU_M052_AP_8
  AfterMake: cmd.exe /C copy "%L" "..\@L.FLM"
  c flags: Optim=1
  c define: FLASH_APROM FLASH_8
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
  group Program Functions
    ./: FlashPrg.c
  group Device Description
    ./: FlashDev.c
target M05x_16 APROM (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: NU_M054_AP_16
  AfterMake: cmd.exe /C copy "%L" "..\@L.FLM"
  c flags: Optim=1
  c define: FLASH_APROM FLASH_16
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target M05x_32 APROM (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: NU_M058_AP_32
  AfterMake: cmd.exe /C copy "%L" "..\@L.FLM"
  c flags: Optim=1
  c define: FLASH_APROM FLASH_32
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target M05x_64 APROM (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: NU_M0516_AP_64
  AfterMake: cmd.exe /C copy "%L" "..\@L.FLM"
  c flags: Optim=1
  c define: FLASH_APROM FLASH_64
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target M05x_4 LDROM (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: NU_M05x_LD_4
  AfterMake: cmd.exe /C copy "%L" "..\@L.FLM"
  c flags: Optim=1
  c define: FLASH_LDROM
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target M05x DATA (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: NU_M05x_DAT
  AfterMake: cmd.exe /C copy "%L" "..\@L.FLM"
  c flags: Optim=1
  c define: FLASH_DATA
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target M05x CFG (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: NU_M05x_CFG
  AfterMake: cmd.exe /C copy "%L" "..\@L.FLM"
  c flags: Optim=1
  c define: FLASH_CFG
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
