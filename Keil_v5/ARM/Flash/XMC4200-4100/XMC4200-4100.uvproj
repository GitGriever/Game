# Keil uVision project XMC4200-4100.uvproj, settings and files
target XMC4200_4100_256 (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: XMC4200_4100_256
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=3
  c define: FLASH_MEM XMC4200_4100_256
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
  group Program Functions
    ./: FlashPrg.c
  group Device Description
    ./: FlashDev.c
target XMC4200_4100c_256 (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: XMC4200_4100c_256
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=3
  c define: FLASH_MEM XMC4200_4100c_256
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target XMC4200_4100_128 (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: XMC4200_4100_128
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=3
  c define: FLASH_MEM XMC4200_4100_128
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target XMC4200_4100c_128 (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: XMC4200_4100c_128
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=3
  c define: FLASH_MEM XMC4200_4100c_128
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target XMC4200_4100_64 (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: XMC4200_4100_64
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=3
  c define: FLASH_MEM XMC4200_4100_64
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target XMC4200_4100c_64 (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: XMC4200_4100c_64
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=3
  c define: FLASH_MEM XMC4200_4100c_64
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
