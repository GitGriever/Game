# Keil uVision project LM3S_256.uvproj, settings and files
target LM3S_256 (ARM-ADS)
  device: LM3S310 Luminary Micro
  cpu: IRAM(0x20000000-0x20000FFF) IROM(0-0x3FFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: LM3S_256
  AfterMake: cmd.exe /C copy Out\LM3S_256.axf ..\LM3S_256.FLM
  c flags: Optim=3
  c include: ..\..\RV31\LIB\Luminary
  memory RVCT4: ROM 0x0 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x1000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
  group Program Functions
    ./: FlashPrg.c
  group Device Description
    ./: FlashDev.c
