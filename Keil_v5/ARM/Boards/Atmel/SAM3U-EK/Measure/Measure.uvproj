# Keil uVision project Measure.uvproj, settings and files
target Simulator (ARM-ADS)
  device: SAM3U4E Atmel
  cpu: IRAM(0x20000000-0x20007FFF) IRAM2(0x20080000-0x20083FFF) IROM(0x80000-0x9FFFF) IROM2(0x100000-0x11FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: Measure
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x80000 size 0x20000
  memory RVCT5: ROM 0x100000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x20080000 size 0x4000
  group StartUp
    ./: startup_SAM3U.s system_SAM3U.c
  group Source Files
    ./: Retarget.c Serial.c ADC.c LED.c Getline.c Mcommand.c Measure.c
  group Documentation
    ./: Abstract.txt
target SAM3U RAM (ARM-ADS)
  device: SAM3U4E Atmel
  cpu: as above
  output: Measure
  c flags: Optim=1
  c define: __ADC_IRQ
  library: MicroLIB
  memory RVCT4: ROM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x20080000 size 0x4000
target SAM3U Flash (ARM-ADS)
  device: SAM3U4E Atmel
  cpu: as above
  output: Measure
  c flags: Optim=1
  c define: __ADC_IRQ
  library: MicroLIB
  memory RVCT4: ROM 0x80000 size 0x20000
  memory RVCT5: ROM 0x100000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x20080000 size 0x4000
