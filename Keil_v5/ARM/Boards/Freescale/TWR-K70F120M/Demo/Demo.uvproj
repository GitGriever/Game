# Keil uVision project Demo.uvproj, settings and files
target K70F120M (ARM-ADS)
  device: MK70FN1M0xxx12 Freescale Semiconductor
  cpu: IRAM(0x1FFF0000-0x1FFFFFFF) IRAM2(0x20000000-0x2000FFFF) IROM(0x0-0xFFFFF) CLOCK(12000000) CPUTYPE("Cortex-M4")  FPU2 ELITTLE
  output: Demo
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x10000
  group Startup
    ./: startup_MK70F12.s system_MK70F12.c
  group Retarget
    ./: Retarget.c
  group Source Files
    ./: Demo.c ADC.c KBD.c LED.c SER.c
  group Documentation
    ./: Abstract.txt
