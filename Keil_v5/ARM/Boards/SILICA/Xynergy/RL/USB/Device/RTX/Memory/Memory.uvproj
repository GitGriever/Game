# Keil uVision project Memory.uvproj, settings and files
target STM32F217 OTG FS  RTX (ARM-ADS)
  device: STM32F217IG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: Memory
  c flags: Optim=4
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Startup Code
    ./: startup_stm32f2xx.s system_stm32f2xx.c SVC_Table.s
  group Configuration
    ./: usb_config_FS.c RTX_Conf_CM.c
  group USB HW Driver
    ./: usbd_STM32F2xx_FS.c
  group Source
    ./: USBD_Demo.c usbd_user_msc.c DiskImg.c
  group Library
    C:/Keil/ARM/RV31/LIB/: USB_CM3.lib
  group Documentation
    ./: Abstract.txt
