# Keil uVision project Blinky.uvproj, settings and files
target JLink - Flash (ARM-ADS)
  device: TMS470MF06607 Texas Instruments
  cpu: IRAM(0x08000000-0x0800FFFF) IROM(0x0-0x7FFFF) IROM2(0x80000-0x9FFFF) CLOCK(16000000) CPUTYPE("Cortex-M3") EBIG
  output: Blinky
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT5: ROM 0x80000 size 0x20000
  memory RVCT9: RAM 0x8000000 size 0x10000
  group Startup
    ./: startup_TMS470Mx.s system_TMS470Mx.c
  group Source Files
    ./: Blinky.c
  group Documentation
    ./: Abstract.txt
target JLink - RAM (ARM-ADS)
  device: TMS470MF06607 Texas Instruments
  cpu: as above
  output: Blinky
  c flags: Optim=1
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT5: ROM 0x80000 size 0x20000
  memory RVCT9: RAM 0x8004000 size 0xc000
