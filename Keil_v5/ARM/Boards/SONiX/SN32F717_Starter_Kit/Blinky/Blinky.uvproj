# Keil uVision project Blinky.uvproj, settings and files
target SN32F717 Flash JLink (ARM-ADS)
  device: SN32F717 SONiX
  cpu: IRAM(0x20000000-0x20000FFF) IROM(0x0-0x3FFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: Blinky
  c flags: Optim=1
  c define: __USART0
  memory RVCT4: ROM 0x0 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group StartUp
    ./: startup_SN32F710.s system_SN32F710.c
  group Source Files
    ./: Retarget.c Serial.c LED.c Blinky.c
  group Documentation
    ./: Abstract.txt
target SN32F717 Flash (ARM-ADS)
  device: SN32F717 SONiX
  cpu: as above
  output: Blinky
  c flags: Optim=1
  c define: __USART0
  memory RVCT4: ROM 0x0 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x1000
target SN32F717 RAM (ARM-ADS)
  device: SN32F717 SONiX
  cpu: as above
  output: Blinky
  c flags: Optim=1
  c define: __USART0
  library: MicroLIB
  memory RVCT4: ROM 0x20000000 size 0x800
  memory RVCT9: RAM 0x20000800 size 0x800
