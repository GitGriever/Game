# Keil uVision project Blinky.uvproj, settings and files
target Simulator (ARM-ADS)
  device: Cortex-M1 (Altera) ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M1")
  output: Blinky
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT6: RAM 0x20100000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Startup Code
    ./: Startup.s
  group Source Code
    ./: Blinky.c
  group Documentation
    ./: Abstract.txt
target Emulator (ARM-ADS)
  device: Cortex-M1 (Altera) ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M1")
  output: Blinky +hex
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT6: RAM 0x20100000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x4000
