# Keil uVision project Blinky.uvproj, settings and files
target SAM3N RAM (ARM-ADS)
  device: SAM3N4C Atmel
  cpu: IRAM(0x20000000-0x20005FFF) IROM(0x400000-0x43FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: Blinky
  c flags: Optim=1
  c define: __USART
  library: MicroLIB
  memory RVCT4: ROM 0x20000000 size 0x3000
  memory RVCT9: RAM 0x20003000 size 0x3000
  group StartUp
    ./: startup_SAM3N.s system_SAM3N.c
  group GPNVM Bits
    ./: SAM3xGPNVM.s
  group Source Files
    ./: Retarget.c Serial.c LED.c BTN.c Blinky.c
  group Documentation
    ./: Abstract.txt
target SAM3N Flash (ARM-ADS)
  device: SAM3N4C Atmel
  cpu: as above
  output: Blinky
  c flags: Optim=1
  c define: __USART
  library: MicroLIB
  memory RVCT4: ROM 0x400000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x6000
target SAM3N Flash + GPNVM (ARM-ADS)
  device: SAM3N4C Atmel
  cpu: as above
  output: Blinky
  c flags: Optim=1
  c define: __USART
  library: MicroLIB
  memory RVCT4: ROM 0x400000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x6000
