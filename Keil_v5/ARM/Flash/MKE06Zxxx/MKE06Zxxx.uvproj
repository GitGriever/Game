# Keil uVision project MKE06Zxxx.uvproj, settings and files
target MKE06Zxxx_P64KB (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: MKE06Zxxx_P64KB
  AfterMake: cmd.exe /C copy ".\Out\%L" "..\@L.FLM"
  c flags: Optim=3
  c define: MKE06Zxxx_P64KB
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
  group Program Functions
    ./: FlashPrg.c
  group Device Description
    ./: FlashDev.c
target MKE06Zxxx_P128KB (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: MKE06Zxxx_P128KB
  AfterMake: cmd.exe /C copy ".\Out\%L" "..\@L.FLM"
  c flags: Optim=3
  c define: MKE06Zxxx_P128KB
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
