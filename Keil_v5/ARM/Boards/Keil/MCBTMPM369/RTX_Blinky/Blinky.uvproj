# Keil uVision project Blinky.uvproj, settings and files
target TMPM369 Flash (ARM-ADS)
  device: TMPM369FDFG Toshiba
  cpu: IRAM(0x20000000-0x200007FF) IRAM2(0x20000800-0x2001FFFF) IROM(0-0x07FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Blinky
  c flags: Optim=1
  c define: __ADC_IRQ
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x800
  memory RVCT10: RAM 0x20000800 size 0x1f800
  group StartUp
    ./: startup_TMPM369.s system_TMPM369.c
  group RTX Configuration
    ./: RTX_Conf_CM.c
  group Source Files
    ./: LED.c Blinky.c
  group Documentation
    ./: Abstract.txt
target TMPM369 RAM (ARM-ADS)
  device: TMPM369FDFG Toshiba
  cpu: as above
  output: Blinky
  c flags: Optim=1
  c define: __ADC_IRQ
  library: MicroLIB
  memory RVCT4: ROM 0x20000800 size 0x1f800
  memory RVCT9: RAM 0x20000000 size 0x800
