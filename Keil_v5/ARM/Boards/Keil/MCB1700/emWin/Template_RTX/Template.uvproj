# Keil uVision project Template.uvproj, settings and files
target MCB1700 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: Template
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c include: C:\Keil\ARM\Segger\emWin\Include
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Startup
    ./: startup_LPC17xx.s system_LPC17xx.c
  group RTX Configuration
    ./: RTX_Conf_CM.c
  group LCD Driver
    ./: LCDConf.c LCD_X_SPI_LPC1700.c
  group GUI Library
    ./: GUIConf.c GUI_X_RTX.c
    C:/Keil/ARM/Segger/emWin/Lib/: GUI_CM3.lib
  group Source Code
    ./: main.c
  group Documentation
    ./: Abstract.txt
target MCB1700 LCD_LG (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: as above
  output: Template
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c include: C:\Keil\ARM\Segger\emWin\Include
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
