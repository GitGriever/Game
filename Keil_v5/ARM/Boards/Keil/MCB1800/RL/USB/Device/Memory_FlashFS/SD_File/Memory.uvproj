# Keil uVision project Memory.uvproj, settings and files
target LPC1857_USB0 Flash (ARM-ADS)
  device: LPC1850 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10017FFF) IRAM2(0x20000000-0x2000FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: Memory
  AfterMake: $K\ARM\BIN\ElfDwT.exe !L BASEADDRESS(0x1A000000)
  c flags: Optim=4
  asm define: NO_CRP
  memory RVCT4: ROM 0x1a000000 size 0x80000
  memory RVCT5: ROM 0x1b000000 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x10000
  group Startup Code
    ./: startup_LPC18xx.s system_LPC18xx.c
  group Configuration
    ./: File_Config.c usb_config_USB0.c usb_config_USB1.c
  group Drivers
    ./: LED_LPC18xx.c KBD_LPC18xx.c Serial_LPC18xx.c GLCD_LPC18xx.c SDIO_LPC18xx.c
  group File System
    ./: Retarget.c
    C:/Keil/ARM/RV31/LIB/: FS_CM3.lib
  group USB
    C:/Keil/ARM/RV31/LIB/: USB_CM3.lib
    ./: usbd_LPC18xx_USB0.c usbd_LPC18xx_USB1.c usbd_user_msc.c
  group Main Code
    ./: Getline.c SD_File.c Memory.c
  group Documentation
    ./: Abstract.txt
target LPC1850_USB0 Ext. Flash (ARM-ADS)
  device: LPC1850 NXP (founded by Philips)
  cpu: as above
  output: Memory
  c flags: Optim=4
  asm define: NO_CRP
  memory RVCT1: ROM 0x1c000000 size 0x1000000
  memory RVCT9: RAM 0x10000000 size 0x18000
  memory RVCT10: RAM 0x20000000 size 0x10000
target LPC1857_USB1 Flash (ARM-ADS)
  device: LPC1850 NXP (founded by Philips)
  cpu: as above
  output: Memory
  AfterMake: $K\ARM\BIN\ElfDwT.exe !L BASEADDRESS(0x1A000000)
  c flags: Optim=4
  asm define: NO_CRP
  memory RVCT4: ROM 0x1a000000 size 0x80000
  memory RVCT5: ROM 0x1b000000 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x10000
target LPC1850_USB1 Ext. Flash (ARM-ADS)
  device: LPC1850 NXP (founded by Philips)
  cpu: as above
  output: Memory
  c flags: Optim=4
  asm define: NO_CRP
  memory RVCT1: ROM 0x1c000000 size 0x1000000
  memory RVCT9: RAM 0x10000000 size 0x18000
  memory RVCT10: RAM 0x20000000 size 0x10000
