# Keil uVision project Blinky.uvproj, settings and files
target HT32F1253 Flash (ARM-ADS)
  device: HT32F1253 Holtek
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x00000000-0x00007BFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Blinky
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x7c00
  memory RVCT9: RAM 0x20000000 size 0x2000
  group StartUp
    ./: startup_ht32f125x.s system_ht32f125x.c
  group RTX Cofiguration
    ./: RTX_Conf_CM.c
  group Source Files
    ./: LED.c Blinky.c
  group Documentation
    ./: Abstract.txt
target HT32F1253 RAM (ARM-ADS)
  device: HT32F1253 Holtek
  cpu: as above
  output: Blinky
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x20000000 size 0x1800
  memory RVCT9: RAM 0x20001800 size 0x800
