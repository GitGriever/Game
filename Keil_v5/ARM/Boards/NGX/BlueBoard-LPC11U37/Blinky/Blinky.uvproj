# Keil uVision project Blinky.uvproj, settings and files
target LPC11U37 Flash (ARM-ADS)
  device: LPC11U37/401 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10001FFF) IRAM2(0x20004000-0x200047FF) IROM(0-0x1FFFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: Blinky
  c flags: Optim=1
  c define: __ADC_IRQ __USE_LCD
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x10000000 size 0x2000
  memory RVCT10: RAM 0x20004000 size 0x800
  group StartUp
    ./: startup_LPC11Uxx.s system_LPC11Uxx.c
  group Source Files
    ./: Retarget.c Serial.c ADC.c LED.c IRQ.c Blinky.c GLCD.c
  group Documentation
    ./: Abstract.txt
target LPC11U37 RAM (ARM-ADS)
  device: LPC11U37/401 NXP (founded by Philips)
  cpu: as above
  output: Blinky
  c flags: Optim=1
  c define: __ADC_IRQ __USE_LCD
  library: MicroLIB
  memory RVCT4: ROM 0x10000000 size 0x2000
  memory RVCT10: RAM 0x20004000 size 0x800
