# Keil uVision project FlexMem_Cfg.uvproj, settings and files
target K40 - FlexMemory Config. (ARM-ADS)
  device: MK40X256VMD100 Freescale Semiconductor
  cpu: IRAM(0x1FFF8000-0x1FFFFFFF) IRAM2(0x20000000-0x20007FFF) IROM(0x0-0x3FFFF) IROM2(0x10000000-0x1003FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE
  output: FlexMem_Cfg
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x10000000 size 0x40000
  memory RVCT9: RAM 0x1fff8000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x8000
  scatter file: .\scatter\FlexNVM_Cfg.sct
  group FlexMemory Configuration
    ./: MKxxDataIFR.s
  group Documentation
    ./: Abstract.txt
