# Keil uVision project Memory.uvproj, settings and files
target MCBSTM32F400_FS RTX (ARM-ADS)
  device: STM32F407IG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: Memory
  c flags: Optim=4
  c define: __MCBSTM32F400
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Startup Code
    ./: startup_stm32f40_41xxx.s system_stm32f4xx.c SVC_Table.s
  group Configuration
    ./: usb_config_FS.c usb_config_HS.c RTX_Conf_CM.c
  group USB HW Driver
    ./: usbd_STM32F4xx_FS.c usbd_STM32F4xx_HS.c
  group Source
    ./: USBD_Demo.c usbd_user_msc.c DiskImg.c GLCD_16bitIF_STM32F4xx.c
  group Library
    C:/Keil/ARM/RV31/LIB/: USB_CM3.lib
  group Documentation
    ./: Abstract.txt
target MCBSTM32F400_HS RTX (ARM-ADS)
  device: STM32F407IG STMicroelectronics
  cpu: as above
  output: Memory
  c flags: Optim=4
  c define: __MCBSTM32F400
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
