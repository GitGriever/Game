# Keil uVision project VirtualCOM.uvproj, settings and files
target LPC4350 USB0 Ext Flash (ARM-ADS)
  device: LPC4350 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x1001FFFF) IRAM2(0x20000000-0x2000FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") FPU2
  output: VirtualCOM
  c flags: Optim=4
  asm define: NO_CRP
  memory RVCT1: ROM 0x1c000000 size 0x1000000
  memory RVCT9: RAM 0x10000000 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x10000
  group Startup Files
    ./: startup_LPC43xx.s system_LPC43xx.c SVC_Table.s
  group Configuration
    ./: RTX_Conf_CM.c usb_config_USB0.c usb_config_USB1.c
  group USB HW Driver
    ./: usbd_LPC43xx_USB0.c usbd_LPC43xx_USB1.c
  group Source
    ./: USBD_Demo.c GLCD_LPC43xx.c UART_LPC43xx.c
    ./: usbd_user_cdc_acm.c
  group Library
    C:/Keil/ARM/RV31/LIB/: USB_CM3.lib
  group Documentation
    ./: Abstract.txt
target LPC4350 USB1 Ext Flash (ARM-ADS)
  device: LPC4350 NXP (founded by Philips)
  cpu: as above
  output: VirtualCOM
  c flags: Optim=4
  asm define: NO_CRP
  memory RVCT1: ROM 0x1c000000 size 0x1000000
  memory RVCT9: RAM 0x10000000 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x10000
target LPC4357 USB0 Int Flash (ARM-ADS)
  device: LPC4357 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x20000000-0x2000FFFF) IROM(0x1A000000-0x1A07FFFF) IROM2(0x1B000000-0x1B07FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") FPU2
  output: VirtualCOM
  AfterMake: $K\ARM\BIN\ElfDwT.exe !L BASEADDRESS(0x1A000000)
  c flags: Optim=4
  asm define: NO_CRP
  memory RVCT4: ROM 0x1a000000 size 0x80000
  memory RVCT5: ROM 0x1b000000 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x10000
target LPC4357 USB1 Int Flash (ARM-ADS)
  device: LPC4357 NXP (founded by Philips)
  cpu: as above
  output: VirtualCOM
  AfterMake: $K\ARM\BIN\ElfDwT.exe !L BASEADDRESS(0x1A000000)
  c flags: Optim=4
  asm define: NO_CRP
  memory RVCT4: ROM 0x1a000000 size 0x80000
  memory RVCT5: ROM 0x1b000000 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x10000
