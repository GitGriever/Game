# Keil uVision project NUC1xx.uvproj, settings and files
target NUC1xx_32 APROM (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: NUC1xx_AP_32
  AfterMake: cmd.exe /C copy NUC1xx_AP_32.axf ..\NUC1xx_AP_32.FLM
  c flags: Optim=1
  c define: FLASH_APROM FLASH_32
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
  group Program Functions
    ./: FlashPrg.c
  group Device Description
    ./: FlashDev.c
target NUC1xx_36 APROM (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: NUC1xx_AP_36
  AfterMake: cmd.exe /C copy NUC1xx_AP_36.axf ..\NUC1xx_AP_36.FLM
  c flags: Optim=1
  c define: FLASH_APROM FLASH_36
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target NUC1xx_64 APROM (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: NUC1xx_AP_64
  AfterMake: cmd.exe /C copy NUC1xx_AP_64.axf ..\NUC1xx_AP_64.FLM
  c flags: Optim=1
  c define: FLASH_APROM FLASH_64
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target NUC1xx_68 APROM (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: NUC1xx_AP_68
  AfterMake: cmd.exe /C copy NUC1xx_AP_68.axf ..\NUC1xx_AP_68.FLM
  c flags: Optim=1
  c define: FLASH_APROM FLASH_68
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target NUC1xx_128 APROM (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: NUC1xx_AP_128
  AfterMake: cmd.exe /C copy NUC1xx_AP_128.axf ..\NUC1xx_AP_128.FLM
  c flags: Optim=1
  c define: FLASH_APROM FLASH_128
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target NUC1xx_4 LDROM (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: NUC1xx_LD_4
  AfterMake: cmd.exe /C copy NUC1xx_LD_4.axf ..\NUC1xx_LD_4.FLM
  c flags: Optim=1
  c define: FLASH_LDROM
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target NUC1xx DATA (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: NUC1xx_DAT
  AfterMake: cmd.exe /C copy NUC1xx_DAT.axf ..\NUC1xx_DAT.FLM
  c flags: Optim=1
  c define: FLASH_DATA
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target NUC1xx CFG (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: NUC1xx_CFG
  AfterMake: cmd.exe /C copy NUC1xx_CFG.axf ..\NUC1xx_CFG.FLM
  c flags: Optim=1
  c define: FLASH_CFG
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
