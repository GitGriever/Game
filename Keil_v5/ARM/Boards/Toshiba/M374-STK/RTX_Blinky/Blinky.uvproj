# Keil uVision project Blinky.uvproj, settings and files
target TMPM374 Flash (ARM-ADS)
  device: TMPM374FWUG Toshiba
  cpu: IRAM(0x20000000-0x200017FF) IROM(0-0x0001FFFF) CLOCK(10000000) CPUTYPE("Cortex-M3")
  output: Blinky
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x1800
  group StartUp
    ./: startup_TMPM374.s system_TMPM374.c
  group RTX Configuration
    ./: RTX_Conf_CM.c
  group Source Files
    ./: LED.c Blinky.c
  group Documentation
    ./: Abstract.txt
