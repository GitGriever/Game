# Keil uVision project STM32L-Discovery.uvproj, settings and files
target STM32L-Discovery (ARM-ADS)
  device: STM32L152RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM32L-Discovery
  c flags: Optim=1
  c define: STM32L1XX_MD STM32L15XXB_128K USE_STDPERIPH_DRIVER
  c include: ..\STM32L1xx_StdPeriph_Driver\inc;..\STM32_TouchSensing_Driver\inc;..\Board;.\
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x3c00
  memory RVCT10: RAM 0x20003c00 size 0x400
  group User
    ./: startup_stm32l1xx_md.s system_stm32l1xx.c stm32l1xx_it.c main.c icc_measure_Ram.c icc_measure.c discover_functions.c
  group STM32L1xx_StdPeriph_Driver
    ../STM32L1xx_StdPeriph_Driver/src/: misc.c stm32l1xx_adc.c stm32l1xx_exti.c stm32l1xx_flash.c stm32l1xx_gpio.c stm32l1xx_lcd.c stm32l1xx_pwr.c stm32l1xx_rcc.c stm32l1xx_rtc.c stm32l1xx_syscfg.c
  group TouchSensing Driver
    ../STM32_TouchSensing_Driver/src/: stm32_tsl_api.c stm32_tsl_multichannelkey.c stm32_tsl_services.c stm32_tsl_singlechannelkey.c stm32_tsl_timebase.c stm32l15x_tsl_ct_acquisition.c
  group STM32L-Discovery
    ../Board/: stm32l_discovery_lcd.c
  group DOC
    ./: Readme.txt
