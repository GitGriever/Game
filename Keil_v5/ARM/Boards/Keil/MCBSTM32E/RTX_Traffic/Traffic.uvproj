# Keil uVision project Traffic.uvproj, settings and files
target Simulator (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Traffic
  c flags: Optim=4
  c define: STM32F10X_HD
  c include: .
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group StartUp
    ./: startup_stm32f10x_hd.s system_stm32f10x.c
  group RTX Configuration
    ./: RTX_Conf_CM.c
  group Source Files
    ./: Serial.c Getline.c Traffic.c GLCD_16bitIF_STM32.c LED.c Retarget.c
  group Documentation
    ./: Abstract.txt
target STM32F103 Flash (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: as above
  output: Traffic
  c flags: Optim=1
  c define: STM32F10X_HD
  c include: .
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
target STM32F103 RAM (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: as above
  output: Traffic
  c flags: Optim=1
  c define: STM32F10X_HD VECT_TAB_SRAM
  c include: .
  library: MicroLIB
  memory RVCT4: ROM 0x20000000 size 0x8000
  memory RVCT9: RAM 0x20008000 size 0x8000
