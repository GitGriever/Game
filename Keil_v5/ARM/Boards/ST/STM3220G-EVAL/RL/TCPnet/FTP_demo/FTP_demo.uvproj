# Keil uVision project FTP_demo.uvproj, settings and files
target STM3220G-EVAL (ARM-ADS)
  device: STM32F207IG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: FTP_demo
  c flags: Optim=4
  c define: __STM_EVAL
  c include: ..\Library
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Source Files
    ./: FTP_demo.c FTP_uif.c
  group Configuration Files
    ./: Net_Config.c Net_Debug.c File_Config.c Retarget.c startup_stm32f2xx.s
  group Library
    C:/Keil/ARM/RV31/LIB/: TCP_CM3.lib TCPD_CM3.lib FS_CM3.lib
    ../Library/: system_stm32f2xx.c ETH_STM32F2xx.c GLCD_16bitIF_STM32F2xx.c SDIO_STM32F2xx.c
  group Documentation
    ./: Abstract.txt
target STM3220G-EVAL Debug (ARM-ADS)
  device: STM32F207IG STMicroelectronics
  cpu: as above
  output: FTP_demo
  c flags: Optim=4
  c define: DEBUG __STM_EVAL
  c include: ..\Library;.\SRC
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
