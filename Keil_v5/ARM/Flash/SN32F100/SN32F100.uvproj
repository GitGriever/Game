# Keil uVision project SN32F100.uvproj, settings and files
target SN32F100_64 USER_ROM (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: SN32F100_64
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=3
  c define: USER_ROM
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
  group Program Functions
    ./: FlashPrg.c SN32F100_FlashCtrl.lib
  group Device Description
    ./: FlashDev.c
