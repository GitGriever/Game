# Keil uVision project Blinky.uvproj, settings and files
target XMC1200 RAM (ARM-ADS)
  device: XMC1200-200 Infineon
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0x10001000-0x10032FFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: Blinky
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x20000200 size 0x1e00
  memory RVCT9: RAM 0x20002000 size 0x2000
  memory RVCT10: RAM 0x20000000 size 0x200
  group StartUp
    ./: startup_XMC1200.s system_XMC1200.c
  group RTX Configuration
    ./: RTX_Conf_CM.c
  group Source Files
    ./: LED.c Blinky.c
  group Documentation
    ./: Abstract.txt
target XMC1200 Flash (ARM-ADS)
  device: XMC1200-200 Infineon
  cpu: as above
  output: Blinky
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x10001000 size 0x32000
  memory RVCT9: RAM 0x20000000 size 0x4000
