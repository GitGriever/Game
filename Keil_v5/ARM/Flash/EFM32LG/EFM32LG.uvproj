# Keil uVision project EFM32LG.uvproj, settings and files
target EFM32LG.FLM (ARM-ADS)
  device: EFM32LG990F256 Energy Micro
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(48000000) CPUTYPE("Cortex-M3")
  output: EFM32LG
  AfterMake: cmd.exe /C copy EFM32LG.axf ..\EFM32LG.FLM
  c flags: Optim=4
  c define: EFM32LG990F256
  c include: ..\..\RV31\LIB\EnergyMicro\emlib\inc
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
  group Program Functions
    ./: FlashPrg.c
  group Device Description
    ./: FlashDev.c
