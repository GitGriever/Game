# Keil uVision project Blinky.uvproj, settings and files
target A2F200M3F Flash (ARM-ADS)
  device: A2F200M3F Actel
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x00000000-0x0003FFFF) CLOCK(20000000) CPUTYPE("Cortex-M3")
  output: Blinky
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Startup Code
    ./: startup_a2fxxxm3.s
  group System Code
    ./: system_a2fxxxm3.c
  group Core Code
    ./: core_cm3.c
  group Source Code
    ./: Blinky.c
  group Documentation
    ./: Abstract.txt
