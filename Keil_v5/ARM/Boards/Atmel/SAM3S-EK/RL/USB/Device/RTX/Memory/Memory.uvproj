# Keil uVision project Memory.uvproj, settings and files
target SAM3S-EK RTX (ARM-ADS)
  device: SAM3S4C Atmel
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x400000-0x43FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: Memory
  c flags: Optim=4
  memory RVCT4: ROM 0x400000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Startup Code
    ./: startup_SAM3S.s system_SAM3S.c SVC_Table.s
  group Configuration
    ./: RTX_Conf_CM.c usb_config.c
  group USB HW Driver
    ./: usbd_SAM3S.c
  group Source
    ./: USBD_Demo.c DiskImg.c usbd_user_msc.c GLCD_8bitIF_SAM3S.c
  group Library
    C:/Keil/ARM/RV31/LIB/: USB_CM3.lib
  group Documentation
    ./: Abstract.txt
