# Keil uVision project Blinky.uvproj, settings and files
target ULink - Flash (ARM-ADS)
  device: MK20DX128xxx5 Freescale Semiconductor
  cpu: IRAM(0x1FFFE000-0x1FFFFFFF) IRAM2(0x20000000-0x20001FFF) IROM(0x0-0x1FFFF) IROM2(0x10000000-0x10007FFF) CLOCK(12000000) CPUTYPE("Cortex-M4") ELITTLE
  output: Blinky
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT5: ROM 0x10000000 size 0x8000
  memory RVCT9: RAM 0x1fffe000 size 0x2000
  memory RVCT10: RAM 0x20000000 size 0x2000
  group Startup
    ./: startup_MK20D5.s system_MK20D5.c
  group Source Files
    ./: Blinky.c
  group RTX Configuration
    ./: RTX_Conf_CM.c
  group Documentation
    ./: Abstract.txt
target ULink - RAM (ARM-ADS)
  device: MK20DX128xxx5 Freescale Semiconductor
  cpu: as above
  output: Blinky
  c flags: Optim=1
  memory RVCT4: ROM 0x1fffe000 size 0x2000
  memory RVCT5: ROM 0x10000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2000
target ULinkPro - Flash (ARM-ADS)
  device: MK20DX128xxx5 Freescale Semiconductor
  cpu: as above
  output: Blinky
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT5: ROM 0x10000000 size 0x8000
  memory RVCT9: RAM 0x1fffe000 size 0x2000
  memory RVCT10: RAM 0x20000000 size 0x2000
target ULinkPro - RAM (ARM-ADS)
  device: MK20DX128xxx5 Freescale Semiconductor
  cpu: as above
  output: Blinky
  c flags: Optim=1
  memory RVCT4: ROM 0x1fffe000 size 0x2000
  memory RVCT5: ROM 0x10000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2000
target PE OSJTAG-Flash (ARM-ADS)
  device: MK20DX128xxx5 Freescale Semiconductor
  cpu: as above
  output: Blinky
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT5: ROM 0x10000000 size 0x8000
  memory RVCT9: RAM 0x1fffe000 size 0x2000
  memory RVCT10: RAM 0x20000000 size 0x2000
target PE OSJTAG-RAM (ARM-ADS)
  device: MK20DX128xxx5 Freescale Semiconductor
  cpu: as above
  output: Blinky
  c flags: Optim=1
  memory RVCT4: ROM 0x1fffe000 size 0x2000
  memory RVCT5: ROM 0x10000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2000
