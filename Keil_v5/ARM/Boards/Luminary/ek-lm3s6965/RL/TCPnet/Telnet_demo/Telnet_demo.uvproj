# Keil uVision project Telnet_demo.uvproj, settings and files
target LM3S6965 (ARM-ADS)
  device: LM3S6965 Luminary Micro
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0-0x3FFFF) CLOCK(6000000) CPUTYPE("Cortex-M3")
  output: Telnet_demo
  c flags: Optim=4
  c define: rvmdk PART_LM3S6965
  c include: ..\Library; C:/Keil/ARM/RV31/LIB/Luminary
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source Files
    ./: Telnet_demo.c Telnet_uif.c
  group Configuration Files
    ./: Net_Config.c Net_Debug.c startup_rvmdk.S
  group Library
    C:/Keil/ARM/RV31/LIB/: TCP_CM3.lib TCPD_CM3.lib
    C:/Keil/ARM/RV31/LIB/Luminary/: driverlib-cm3.lib
    ../Library/: LM3S_EMAC.c
    ../../../: rit128x96x4.c
  group Documentation
    ./: Abstract.txt
target LM3S6965 Debug (ARM-ADS)
  device: LM3S2965 Luminary Micro
  cpu: as above
  output: Telnet_demo
  c flags: Optim=4
  c define: rvmdk PART_LM3S6965
  c include: ..\Library; C:/Keil/ARM/RV31/LIB/Luminary
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
