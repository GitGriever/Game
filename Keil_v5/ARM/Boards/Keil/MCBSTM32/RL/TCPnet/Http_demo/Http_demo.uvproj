# Keil uVision project Http_demo.uvproj, settings and files
target MCBSTM32 (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Http_demo
  c flags: Optim=4
  c define: STM32F10X_MD
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group HTTP Files
    ./Web/: Web.inp index.htm network.cgi leds.cgi system.cgi tcp.cgi language.cgi ad.cgi ad.cgx buttons.cgi buttons.cgx pg_header.inc pg_footer.inc xml_http.js
  group StartUp
    ./: startup_stm32f10x_md.s system_stm32f10x.c
  group Configuration Files
    ./: Net_Config.c
  group Source Files
    ./: HTTP_demo.c HTTP_CGI.c Serial_STM32x.c
    ./Web/: WEB.C
  group Library
    C:/Keil/ARM/RV31/LIB/: TCP_CM3.lib
    ./: LCD_4bit.c
  group Documentation
    ./: Abstract.txt
