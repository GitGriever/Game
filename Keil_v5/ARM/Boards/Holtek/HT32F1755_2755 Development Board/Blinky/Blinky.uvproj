# Keil uVision project Blinky.uvproj, settings and files
target HT32F1755 RAM (ARM-ADS)
  device: HT32F1755 Holtek
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x00000000-0x0001FBFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Blinky
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x20000000 size 0x4000
  memory RVCT9: RAM 0x20004000 size 0x4000
  group StartUp
    ./: startup_ht32f175x_275x.s system_ht32f175x_275x.c
  group Flash Options & data
    ./: ht32f175x_275x_op.s userdata.dat
  group Source Files
    ./: Retarget.c Serial.c ADC.c LED.c IRQ.c Blinky.c
  group Documentation
    ./: Abstract.txt
target HT32F1755 Flash (ARM-ADS)
  device: HT32F1755 Holtek
  cpu: as above
  output: Blinky
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x1fc00
  memory RVCT9: RAM 0x20000000 size 0x8000
target HT32F1755 OPT (ARM-ADS)
  device: HT32F1755 Holtek
  cpu: as above
  output: Blinky
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x1fc00
  memory RVCT9: RAM 0x20000000 size 0x8000
target HT32F1755 SWO (ARM-ADS)
  device: HT32F1755 Holtek
  cpu: as above
  output: Blinky
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x1fc00
  memory RVCT9: RAM 0x20000000 size 0x8000
