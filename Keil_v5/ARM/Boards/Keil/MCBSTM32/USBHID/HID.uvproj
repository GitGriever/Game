# Keil uVision project HID.uvproj, settings and files
target STM32F103 Flash (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: hid
  c flags: Optim=1
  c define: STM32F10X_MD
  c include: .\
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group StartUp
    ./: startup_stm32f10x_md.s system_stm32f10x.c
  group USB Configuration
    ./: usbcfg_STM32F10x.h
  group Source Code
    ./: usbhw_STM32F10x.c usbuser.c usbdesc.c usbcore.c hiduser.c LCD_4bit.c demo.c
  group Documentation
    ./: Abstract.txt
