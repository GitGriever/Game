# Keil uVision project ProgOnce_Cfg.uvproj, settings and files
target ProgOnce_Cfg - ULINK (ARM-ADS)
  device: MKL25Z128xxx4 Freescale Semiconductor
  cpu: IRAM(0x1FFFF000-0x1FFFFFFF) IRAM2(0x20000000-0x20002FFF) IROM(0x0-0x1FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0+") ELITTLE
  output: ProOnceMem
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1ffff000 size 0x1000
  memory RVCT10: RAM 0x20000000 size 0x3000
  scatter file: .\scatter\ProgOnce.sct
  group Program Once Memory
    ./: MKxxFlashIFR.s
  group Documentation
    ./: Abstract.txt
target ProgOnce_Cfg - ULINKPro (ARM-ADS)
  device: MKL25Z128xxx4 Freescale Semiconductor
  cpu: as above
  output: ProOnceMem
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1ffff000 size 0x1000
  memory RVCT10: RAM 0x20000000 size 0x3000
  scatter file: .\scatter\ProgOnce.sct
