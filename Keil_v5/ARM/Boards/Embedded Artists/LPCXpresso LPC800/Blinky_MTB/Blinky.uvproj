# Keil uVision project Blinky.uvproj, settings and files
target ULink - MTB (ARM-ADS)
  device: LPC812M101 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10000FFF) IROM(0-0x3FFF) CLOCK(12000000) CPUTYPE("Cortex-M0+")
  output: Blinky
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x4000
  memory RVCT9: RAM 0x10000000 size 0x800
  group StartUp
    ./: startup_LPC8xx.s system_LPC8xx.c
  group Source Files
    ./: LED.c Blinky.c CMP.c
  group Documentation
    ./: Abstract.txt
target ULinkPro - MTB (ARM-ADS)
  device: LPC812M101 NXP (founded by Philips)
  cpu: as above
  output: Blinky
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x4000
  memory RVCT9: RAM 0x10000000 size 0x800
