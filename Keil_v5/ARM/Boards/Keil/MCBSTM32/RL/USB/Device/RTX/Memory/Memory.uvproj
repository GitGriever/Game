# Keil uVision project Memory.uvproj, settings and files
target MCBSTM32 RTX (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Memory
  c flags: Optim=4
  c define: STM32F10X_MD
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group StartUp
    ./: SVC_Table.s startup_stm32f10x_md.s system_stm32f10x.c
  group Configuration
    ./: RTX_Conf_CM.c usb_config.c
  group USB HW Driver
    ./: usbd_STM32F103.c
  group Source
    ./: USBD_Demo.c DiskImg.c usbd_user_msc.c LCD_4bit.c
  group Library
    C:/Keil/ARM/RV31/LIB/: USB_CM3.lib
  group Documentation
    ./: Abstract.txt
