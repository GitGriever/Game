# Keil uVision project ATSAM4.uvproj, settings and files
target ATSAM4C_256 (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: ATSAM4C_256
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=3
  c define: ATSAM4C_256 FLASH_MEM
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
  group Program Functions
    ./: FlashPrg.c
  group Device Description
    ./: FlashDev.c
target ATSAM4C_512 (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: ATSAM4C_512
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=3
  c define: ATSAM4C_512 FLASH_MEM
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target ATSAM4C_1024 (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: ATSAM4C_1024
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=3
  c define: ATSAM4C_1024 FLASH_MEM
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target ATSAM4C32_2048 (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: ATSAM4C32_2048
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=3
  c define: ATSAM4C32_2048 FLASH_MEM
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target ATSAM4E_512 (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: ATSAM4E_512
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=3
  c define: ATSAM4E_512 FLASH_MEM
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target ATSAM4E_1024 (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: ATSAM4E_1024
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=3
  c define: ATSAM4E_1024 FLASH_MEM
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target ATSAM4N_256 (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: ATSAM4N_256
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=3
  c define: ATSAM4N_256 FLASH_MEM
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target ATSAM4N_512 (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: ATSAM4N_512
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=3
  c define: ATSAM4N_512 FLASH_MEM
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target ATSAM4N_1024 (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: ATSAM4N_1024
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=3
  c define: ATSAM4N_1024 FLASH_MEM
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target ATSAM4S_128 (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: ATSAM4S_128
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=3
  c define: ATSAM4S_128 FLASH_MEM
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target ATSAM4S_256 (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: ATSAM4S_256
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=3
  c define: ATSAM4S_256 FLASH_MEM
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target ATSAM4S_512 (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: ATSAM4S_512
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=3
  c define: ATSAM4S_512 FLASH_MEM
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target ATSAM4S_1024 (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: ATSAM4S_1024
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=3
  c define: ATSAM4S_1024 FLASH_MEM
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target ATSAM4SD_1024 (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: ATSAM4SD_1024
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=3
  c define: ATSAM4SD_1024 FLASH_MEM
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target ATSAM4SD_2048 (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: ATSAM4SD_2048
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=3
  c define: ATSAM4SD_2048 FLASH_MEM
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target ATSAM4SP_2048 (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: ATSAM4SP_2048
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=3
  c define: ATSAM4SP_2048 FLASH_MEM
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target ATSAM4S_GPNVM (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: ATSAM4S_GPNVM
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=3
  c define: ATSAM4S_1024 FLASH_GPNVM
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
