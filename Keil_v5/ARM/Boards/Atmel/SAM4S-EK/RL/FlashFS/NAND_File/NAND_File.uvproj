# Keil uVision project NAND_File.uvproj, settings and files
target SAM4S16C Flash (ARM-ADS)
  device: SAM4S16C Atmel
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x400000-0x4FFFFF) CLOCK(12000000) CPUTYPE("Cortex-M4")
  output: NAND_File
  c flags: Optim=4
  memory RVCT4: ROM 0x400000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Startup Code
    ./: startup_SAM4S.s system_SAM4S.c
  group Configuration
    ./: File_Config.c
  group Retarget
    ./: Retarget.c
  group Source
    ./: GLCD_8bitIF_SAM4S.c
    ./: SER.c Getline.c NAND_SAM4S.c NAND_File.c
  group Library
    C:/Keil/ARM/RV31/LIB/: FS_CM3.lib
  group Documentation
    ./: Abstract.txt
