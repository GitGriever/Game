# Keil uVision project TrafficLight.uvproj, settings and files
target M1A3P Flash (ARM-ADS)
  device: Cortex-M1 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M1")
  output: TrafficLight
  c flags: Optim=1
  library: MicroLIB
  memory RVCT1: ROM 0x0 size 0x1000000
  memory RVCT6: RAM 0x10000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x800
  group Startup
    ./: Startup.s
  group Source Code
    ./: APB_GPIO.c APB_Timer.c APB_UART.c APB_Interrupt.c TrafficLightMain.c
  group Documentation
    ./: Abstract.txt
target M1A3P SRAM (ARM-ADS)
  device: Cortex-M1 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M1")
  output: TrafficLight
  c flags: Optim=1
  library: MicroLIB
  memory RVCT1: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x800
