# Keil uVision project VirtualCOM.uvproj, settings and files
target MCBSTM32F400 HS (ARM-ADS)
  device: STM32F407IG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: VirtualCOM
  c flags: Optim=4
  c define: __USART1
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Startup Files
    ./: system_stm32f4xx.c SVC_Table.s startup_stm32f40_41xxx.s
  group Configuration
    ./: usb_config_FS.c usb_config_HS.c RTX_Conf_CM.c
  group USB HW Driver
    ./: usbd_STM32F4xx_FS.c usbd_STM32F4xx_HS.c
  group Source
    ./: USBD_Demo.c GLCD_16bitIF_STM32F4xx.c UART_STM32F4xx.c
    ./: usbd_user_cdc_acm.c
  group Library
    C:/Keil/ARM/RV31/LIB/: USB_CM3.lib
  group Documentation
    ./: Abstract.txt
target MCBSTM32F400 FS (ARM-ADS)
  device: STM32F407IG STMicroelectronics
  cpu: as above
  output: VirtualCOM
  c flags: Optim=4
  c define: __USART1
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
