# Keil uVision project Telnet_demo.uvproj, settings and files
target STM32F200 (ARM-ADS)
  device: STM32F207IG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: Telnet_demo
  c flags: Optim=4
  c include: ..\Library
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Source Files
    ./: Telnet_demo.c Telnet_uif.c
  group Configuration Files
    ./: Net_Config.c Net_Debug.c startup_stm32f2xx.s
  group Library
    C:/Keil/ARM/RV31/LIB/: TCP_CM3.lib TCPD_CM3.lib
    ../Library/: ETH_STM32F2xx.c system_stm32f2xx.c GLCD_16bitIF_STM32F2xx.c LED.c Serial.c ADC.c
  group Documentation
    ./: Abstract.txt
target STM32F200 Debug (ARM-ADS)
  device: STM32F207IG STMicroelectronics
  cpu: as above
  output: Telnet_demo
  c flags: Optim=4
  c include: ..\Library
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
