# Keil uVision project STM32L0xx64.uvproj, settings and files
target STM32L0xx_64 (ARM-ADS)
  device: Cortex-M0+ ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0+") ESEL ELITTLE
  output: STM32L0xx_64
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=1
  c define: FLASH_MEMORY STM32L0xx_64
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
  group Program Functions
    ./: FlashPrg.c
  group Device Description
    ./: FlashDev.c
