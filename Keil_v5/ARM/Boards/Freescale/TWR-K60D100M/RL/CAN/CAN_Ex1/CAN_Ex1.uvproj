# Keil uVision project CAN_Ex1.uvproj, settings and files
target K60DN512 (ARM-ADS)
  device: MK60DN512xxx10 Freescale Semiconductor
  cpu: IRAM(0x1FFF0000-0x1FFFFFFF) IRAM2(0x20000000-0x2000FFFF) IROM(0x0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") ELITTLE
  output: CAN_Ex1
  c flags: Optim=1
  c include: .\
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x10000
  group StartUp
    ./: system_MK60D10.c startup_MK60D10.s
  group RTX Configuration
    ./: RTX_Config.c
  group CAN Core
    ./: CAN_Cfg.h
    C:/Keil/ARM/RL/CAN/SRC/: RTX_CAN.c
  group CAN Driver
    ./: CAN_MK60.c
  group Source
    ./: CAN_Ex1.c ADC.c LED.c
  group Documentation
    ./: Abstract.txt
