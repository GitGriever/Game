# Keil uVision project Blinky.uvproj, settings and files
target Simulator (ARM-ADS)
  device: LM3S6965 Luminary Micro
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0-0x3FFFF) CLOCK(6000000) CPUTYPE("Cortex-M3")
  output: Blinky
  c flags: Optim=1
  c define: rvmdk PART_LM3S6965
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group System Files
    ./: startup_lm3s.s system_lm3s.c lm3s_config.h
  group Source Files
    ./: Blinky.c IRQ.c Serial.c Retarget.c
  group Documentation
    ./: Abstract.txt
target SWO Trace (ARM-ADS)
  device: LM3S6965 Luminary Micro
  cpu: as above
  output: Blinky
  c flags: Optim=1
  c define: rvmdk PART_LM3S6965
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
