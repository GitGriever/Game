# Keil uVision project Http_upload.uvproj, settings and files
target LPC1788 (ARM-ADS)
  device: LPC1788 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x1000FFFF) IRAM2(0x20000000-0x20007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: Http_upload
  c flags: Optim=4
  c include: ..\Library
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x8000
  group HTTP Files
    ./Web/: Web.inp index.htm upload.cgi dir.cgi format.cgi pg_header.inc pg_footer.inc
  group Source Files
    ./: HTTP_upload.c HTTP_CGI.c
    ./Web/: WEB.C
  group Configuration Files
    ./: Net_Config.c File_Config.c HTTP_uif.c Retarget.c startup_LPC177x_8x.s
  group Library
    C:/Keil/ARM/RV31/LIB/: TCP_CM3.lib FS_CM3.lib
    ../Library/: EMAC_LPC177x_8x.c system_LPC177x_8x.c MCI_LPC177x_8x.c LED_LPC177x_8x.c
  group Documentation
    ./: Abstract.txt
