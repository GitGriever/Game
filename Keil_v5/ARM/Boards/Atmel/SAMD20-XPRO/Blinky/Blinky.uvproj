# Keil uVision project Blinky.uvproj, settings and files
target SAMD20 RAM (ARM-ADS)
  device: SAMD20J18 Atmel
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(12000000) CPUTYPE("Cortex-M0+")
  output: Blinky
  c flags: Optim=1
  c define: __SAMD20J18__
  library: MicroLIB
  memory RVCT4: ROM 0x20000000 size 0x4000
  memory RVCT9: RAM 0x20004000 size 0x4000
  group StartUp
    ./: startup_SAMD20.s system_samd20.c
  group Source Files
    ./: Retarget.c Serial.c LED.c BTN.c Blinky.c
  group Documentation
    ./: Abstract.txt
target SAMD20 Flash (ARM-ADS)
  device: SAMD20J18 Atmel
  cpu: as above
  output: Blinky
  c flags: Optim=1
  c define: __SAMD20J18__
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
