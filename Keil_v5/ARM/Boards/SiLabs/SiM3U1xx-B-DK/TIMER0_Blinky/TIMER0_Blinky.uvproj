# Keil uVision project TIMER0_Blinky.uvproj, settings and files
target TIMER0_Blinky (ARM-ADS)
  device: SiM3U167 Silicon Laboratories, Inc.
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x0-0x3FFFF) CLOCK(20000000) CPUTYPE("Cortex-M3")
  output: TIMER0_Blinky
  c flags: Optim=1
  c define: NDEBUG
  c misc: --c99 --gnu
  c include: .;generated;C:\Silabs\32bit\si32-1.0.1\si32Hal\CPU;C:\Silabs\32bit\si32-1.0.1\si32Hal\SI32_Modules;C:\Silabs\32bit\si32-1.0.1\si32Hal\sim3u1xx
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: C:\Silabs\32bit\si32-1.0.1\si32Hal\sim3u1xx\linker_sim3u1xx_arm.sct
  group SiM3xxxx
    C:/Silabs/32bit/si32-1.0.1/si32Hal/CPU/: retarget_arm.c
    C:/Silabs/32bit/si32-1.0.1/si32Hal/sim3u1xx/: startup_sim3u1xx_arm.s system_sim3u1xx.c
    C:/Silabs/32bit/si32-1.0.1/si32Hal/SI32_Modules/: SI32_EXTOSC_A_Type.c SI32_RTC_A_Type.c SI32_PLL_A_Type.c SI32_USB_A_Type.c SI32_SARADC_A_Type.c SI32_SSG_A_Type.c SI32_CAPSENSE_A_Type.c SI32_CMP_A_Type.c SI32_IVC_A_Type.c SI32_IDAC_A_Type.c SI32_EMIF_A_Type.c SI32_EMIFIF_A_Type.c SI32_I2C_A_Type.c SI32_I2S_A_Type.c SI32_SPI_A_Type.c SI32_USART_A_Type.c SI32_UART_A_Type.c SI32_FLASHCTRL_A_Type.c SI32_VMON_A_Type.c SI32_EXTVREG_A_Type.c SI32_VREG_A_Type.c SI32_VREF_A_Type.c SI32_LPTIMER_A_Type.c SI32_TIMER_A_Type.c SI32_EPCA_A_Type.c SI32_EPCACH_A_Type.c SI32_PCA_A_Type.c SI32_PCACH_A_Type.c SI32_WDTIMER_A_Type.c SI32_AES_A_Type.c SI32_CRC_A_Type.c
  group SIM3U1XX
    C:/Silabs/32bit/si32-1.0.1/si32Hal/sim3u1xx/: SI32_PBCFG_A_Type.c SI32_PMU_A_Type.c SI32_LDO_A_Type.c SI32_LOCK_A_Type.c SI32_RSTSRC_A_Type.c
  group TIMER0_Blinky
    ./: main.c myCLKCTRL.c myCPU.c myPB.c myFLASHCTRL0.c myTIMER0.c myUSB0.c myWDTIMER0.c
  group generated
    generated/: gCLKCTRL.c gCPU.c gFLASHCTRL0.c gModes.c gPB.c gTIMER0.c gUSB0.c gWDTIMER0.c
