# Keil uVision project Template.uvproj, settings and files
target MCBSTM32C (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F107VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: Template
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c include: C:\Keil\ARM\Segger\emWin\Include
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Startup
    ./: startup_stm32f10x_cl.s system_stm32f10x_cl.c
  group RTX Configuration
    ./: RTX_Conf_CM.c
  group LCD Driver
    ./: LCDConf.c LCD_X_SPI_STM32.c
  group GUI Library
    ./: GUIConf.c GUI_X_RTX.c
    C:/Keil/ARM/Segger/emWin/Lib/: GUI_CM3.lib
  group Source Code
    ./: main.c
  group Documentation
    ./: Abstract.txt
target MCBSTM32C LCD_LG (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: as above
  output: Template
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c include: C:\Keil\ARM\Segger\emWin\Include
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
