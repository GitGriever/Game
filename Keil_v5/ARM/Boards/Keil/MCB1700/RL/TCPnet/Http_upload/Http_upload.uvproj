# Keil uVision project Http_upload.uvproj, settings and files
target MCB1700 (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: Http_upload
  c flags: Optim=4
  c include: ..\Library
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group HTTP Files
    ./Web/: Web.inp index.htm upload.cgi dir.cgi format.cgi pg_header.inc pg_footer.inc
  group Source Files
    ./: HTTP_upload.c HTTP_CGI.c
    ./Web/: WEB.C
  group Configuration Files
    ./: Net_Config.c File_Config.c HTTP_uif.c Retarget.c startup_LPC17xx.s
  group Library
    C:/Keil/ARM/RV31/LIB/: TCP_CM3.lib FS_CM3.lib
    ../Library/: EMAC_LPC17xx.c SPI_LPC17xx.c GLCD_SPI_LPC1700.c system_LPC17xx.c
  group Documentation
    ./: Abstract.txt
