# Keil uVision project CY8C42xx.uvproj, settings and files
target Cortex-M (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: CY8C42xx
  AfterMake: cmd.exe /C copy "%L" "..\@L.FLM"
  c flags: Optim=1
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
  group Program Functions
    ./: FlashPrg.c
  group Device Description
    ./: FlashDev.c
target ARM7_ARM9 (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: NEW_DEVICE
  AfterMake: cmd.exe /C copy "%L" "..\@L.FLX"
  c flags: Optim=3
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
