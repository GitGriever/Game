# Keil uVision project EFM32WG.uvproj, settings and files
target EFM32WG.FLM (ARM-ADS)
  device: EFM32WG995F64 Energy Micro
  cpu: IRAM(0x20000000-0x20007fff) IROM(0x00000000-0xFFFF) CLOCK(48000000) CPUTYPE("Cortex-M4")
  output: EFM32WG
  AfterMake: cmd.exe /C copy EFM32WG.axf ..\EFM32WG.FLM
  c flags: Optim=4
  c define: EFM32WG990F256
  c include: ..\..\RV31\LIB\EnergyMicro\emlib\inc
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
  group Program Functions
    ./: FlashPrg.c
  group Device Description
    ./: FlashDev.c
