# Keil uVision project Nano100.uvproj, settings and files
target Nano100_8_APROM (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: Nano100_AP_8
  AfterMake: cmd.exe /C copy Nano100_AP_8.axf ..\Nano100_AP_8.FLM
  c flags: Optim=1
  c define: FLASH_APROM FLASH_8
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
  group Program Functions
    ./: FlashPrg.c
  group Device Description
    ./: FlashDev.c
target Nano100_16_APROM (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: Nano100_AP_16
  AfterMake: cmd.exe /C copy Nano100_AP_16.axf ..\Nano100_AP_16.FLM
  c flags: Optim=1
  c define: FLASH_APROM FLASH_16
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target Nano100_32 APROM (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: Nano100_AP_32
  AfterMake: cmd.exe /C copy Nano100_AP_32.axf ..\Nano100_AP_32.FLM
  c flags: Optim=1
  c define: FLASH_APROM FLASH_32
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target Nano100_64 APROM (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: Nano100_AP_64
  AfterMake: cmd.exe /C copy Nano100_AP_64.axf ..\Nano100_AP_64.FLM
  c flags: Optim=1
  c define: FLASH_APROM FLASH_64
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target Nano100_123_APROM (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: Nano100_AP_123
  AfterMake: cmd.exe /C copy Nano100_AP_123.axf ..\Nano100_AP_123.FLM
  c flags: Optim=1
  c define: FLASH_APROM FLASH_123
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target Nano100_4 LDROM (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: Nano100_LD_4
  AfterMake: cmd.exe /C copy Nano100_LD_4.axf ..\Nano100_LD_4.FLM
  c flags: Optim=1
  c define: FLASH_LDROM
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target Nano100 DATA (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: Nano100_DAT
  AfterMake: cmd.exe /C copy Nano100_DAT.axf ..\Nano100_DAT.FLM
  c flags: Optim=1
  c define: FLASH_DATA
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target Nano100 CFG (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: Nano100_CFG
  AfterMake: cmd.exe /C copy Nano100_CFG.axf ..\Nano100_CFG.FLM
  c flags: Optim=1
  c define: FLASH_CFG
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
