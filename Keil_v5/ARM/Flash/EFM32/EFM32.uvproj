# Keil uVision project EFM32.uvproj, settings and files
target EFM32.FLM (ARM-ADS)
  device: EFM32G890F128 Energy Micro
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x1FFFF) CLOCK(32000000) CPUTYPE("Cortex-M3")
  output: EFM32
  AfterMake: cmd.exe /C copy EFM32.axf ..\EFM32.FLM
  c flags: Optim=4
  c define: EFM32G890F128
  c include: ..\..\RV31\LIB\EnergyMicro\emlib\inc
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
  group Program Functions
    ./: FlashPrg.c FlashOS.h
  group Device Description
    ./: FlashDev.c
