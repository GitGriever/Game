# Keil uVision project Blinky.uvproj, settings and files
target NUC140 Flash (ARM-ADS)
  device: NUC140VE3AN Nuvoton
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x1FFFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: Blinky
  c flags: Optim=1
  c define: __ADC_IRQ
  c include: ../Include
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --entry Reset_Handler
  group StartUp
    ./: startup_NUC1xx.s system_NUC1xx.c
  group SourceFiles
    ./: Retarget.c Serial.c LED.c ADC.c IRQ.c Blinky.c
  group Documentation
    ./: Abstract.txt
