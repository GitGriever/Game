# Keil uVision project MKExx.uvproj, settings and files
target MKExx_P128KB (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: MKExx_P128KB
  AfterMake: cmd.exe /C copy ".\Out\%L" "..\@L.FLM"
  c flags: Optim=3
  c define: MKExx_P128KB
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
  group Program Functions
    ./: FlashPrg.c
  group Device Description
    ./: FlashDev.c
target MKExx_P256KB (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: MKExx_P256KB
  AfterMake: cmd.exe /C copy ".\Out\%L" "..\@L.FLM"
  c flags: Optim=3
  c define: MKExx_P256KB
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target MKExx_D8KB (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: MKExx_D8KB
  AfterMake: cmd.exe /C copy ".\Out\%L" "..\@L.FLM"
  c flags: Optim=3
  c define: MKExx_D8KB DFLASH
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
