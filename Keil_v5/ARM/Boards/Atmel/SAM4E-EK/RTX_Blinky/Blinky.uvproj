# Keil uVision project Blinky.uvproj, settings and files
target SAM4E RAM (ARM-ADS)
  device: SAM4E16E Atmel
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x400000-0x4FFFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") FPU2
  output: Blinky
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x20000000 size 0x10000
  memory RVCT9: RAM 0x20010000 size 0x10000
  group StartUp Files
    ./: startup_SAM4E.s system_SAM4E.c
  group RTX Configuration
    ./: RTX_Conf_CM.c
  group Source Files
    ./: GLCD_8bitIF_SAM4E.c LED.c Blinky.c
  group Documentation
    ./: Abstract.txt
target SAM4E Flash (ARM-ADS)
  device: SAM4E16E Atmel
  cpu: as above
  output: Blinky
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x400000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
