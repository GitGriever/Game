# Keil uVision project NAND_File.uvproj, settings and files
target SAM3X Flash (ARM-ADS)
  device: SAM3X8H Atmel
  cpu: IRAM(0x20000000-0x2000FFFF) IRAM2(0x20080000-0x20087FFF) IROM(0x80000-0xFFFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: NAND_File
  c flags: Optim=4
  memory RVCT4: ROM 0x80000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x20080000 size 0x8000
  group Startup Code
    ./: startup_SAM3XA.s system_SAM3XA.c
  group Configuration
    ./: File_Config.c
  group Retarget
    ./: Retarget.c
  group Source
    ./: Serial.c Getline.c NAND_SAM3X.c NAND_File.c
  group Library
    C:/Keil/ARM/RV31/LIB/: FS_CM3.lib
  group Documentation
    ./: Abstract.txt
