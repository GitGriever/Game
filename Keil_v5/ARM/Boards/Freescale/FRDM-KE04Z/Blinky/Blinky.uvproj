# Keil uVision project Blinky.uvproj, settings and files
target CMSIS-DAP -Flash (ARM-ADS)
  device: MKE04Z8xxx4 Freescale Semiconductor
  cpu: IRAM(0x1FFFFF00-0x1FFFFFFF) IRAM2(0x20000000-0x200002FF) IROM(0x0-0x1FFF) CLOCK(8000000) CPUTYPE("Cortex-M0+") ELITTLE
  output: Blinky
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x2000
  memory RVCT9: RAM 0x1fffff00 size 0x100
  memory RVCT10: RAM 0x20000000 size 0x300
  group Soure Files
    ./: Blinky.c
  group Startup files
    ./: system_MKE04Z4.c startup_MKE04Z4.s
  group Documentation
    ./: Abstract.txt
target ULINK-Flash (ARM-ADS)
  device: MKE04Z8xxx4 Freescale Semiconductor
  cpu: as above
  output: Blinky
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x2000
  memory RVCT9: RAM 0x1fffff00 size 0x100
  memory RVCT10: RAM 0x20000000 size 0x300
