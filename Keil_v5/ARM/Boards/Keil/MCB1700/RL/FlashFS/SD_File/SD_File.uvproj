# Keil uVision project SD_File.uvproj, settings and files
target MCB1700 (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: SD_File
  c flags: Optim=4
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Startup Code
    ./: startup_LPC17xx.s system_LPC17xx.c
  group Configuration
    ./: File_Config.c
  group Retarget
    ./: Retarget.c
  group Source
    ./: Getline.c Serial.c SD_File.c SPI_LPC17xx.c GLCD_SPI_LPC1700.c
  group Library
    C:/Keil/ARM/RV31/LIB/: FS_CM3.lib
  group Documentation
    ./: Abstract.txt
