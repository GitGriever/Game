# Keil uVision project ATSAMR21.uvproj, settings and files
target ATSAMR21_64 (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: ATSAMR21_64
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=3
  c define: ATSAMR21_64 FLASH_MEM
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
  group Program Functions
    ./: FlashPrg.c
  group Device Description
    ./: FlashDev.c
target ATSAMR21_128 (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: ATSAMR21_128
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=3
  c define: ATSAMR21_128 FLASH_MEM
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target ATSAMR21_256 (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: ATSAMR21_256
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=3
  c define: ATSAMR21_256 FLASH_MEM
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
