# Keil uVision project Memory.uvproj, settings and files
target STM32F103 Flash (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Memory
  c flags: Optim=4
  c define: STM32F10X_MD
  c include: ..\Library
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Startup Code
    ./: SVC_Table.s startup_stm32f10x_md.s system_stm32f10x.c
  group Configuration
    ./: File_Config.c usb_config.c RTX_Conf_CM.c
  group Drivers
    ./: LED.c KBD.c Serial.c SPI_STM32F103.c LCD_4bit.c
  group File System
    ./: Retarget.c
    C:/Keil/ARM/RV31/LIB/: FS_CM3.lib
  group USB
    C:/Keil/ARM/RV31/LIB/: USB_CM3.lib
    ./: usbd_STM32F103.c usbd_user_msc.c
  group Main Code
    ./: Getline.c SD_File.c Memory.c
  group Documentation
    ./: Abstract.txt
