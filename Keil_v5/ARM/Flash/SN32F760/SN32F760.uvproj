# Keil uVision project SN32F760.uvproj, settings and files
target SN32F760_64 (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: SN32F760_64 +hex
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  AfterMake: fromelf --bin ".\Out\SN32F760_64.axf" --output ".\Out\SN32F760_64.bin"
  c flags: Optim=3
  c define: USER_ROM_64KB
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
  group Program Functions
    ./: FlashPrg.c
  group Device Description
    ./: FlashDev.c
target SN32F750_32 (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: SN32F750_32 +hex
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  AfterMake: fromelf --bin ".\Out\SN32F750_32.axf" --output ".\Out\SN32F750_32.bin"
  c flags: Optim=3
  c define: USER_ROM_32KB
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target SN32F740_16 (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: SN32F740_16 +hex
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  AfterMake: fromelf --bin ".\Out\SN32F740_16.axf" --output ".\Out\SN32F740_16.bin"
  c flags: Optim=3
  c define: USER_ROM_16KB
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target SN32F730_8 (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: SN32F730_8 +hex
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=3
  c define: USER_ROM_8KB
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
