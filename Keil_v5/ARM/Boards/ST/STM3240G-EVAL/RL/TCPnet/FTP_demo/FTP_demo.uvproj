# Keil uVision project FTP_demo.uvproj, settings and files
target STM32F407 (ARM-ADS)
  device: STM32F407IG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: FTP_demo
  c flags: Optim=4
  c define: __STM_EVAL
  c include: ..\Library
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source Files
    ./: FTP_demo.c FTP_uif.c
  group Configuration Files
    ./: Net_Config.c Net_Debug.c File_Config.c Retarget.c startup_stm32f40_41xxx.s
  group Library
    C:/Keil/ARM/RV31/LIB/: TCP_CM3.lib TCPD_CM3.lib FS_CM3.lib
    ../Library/: system_stm32f4xx.c ETH_STM32F4xx.c GLCD_16bitIF_STM32F4xx.c SDIO_STM32F4xx.c LED.c Serial.c
  group Documentation
    ./: Abstract.txt
target STM32F407 Debug (ARM-ADS)
  device: STM32F407IG STMicroelectronics
  cpu: as above
  output: FTP_demo
  c flags: Optim=4
  c define: DEBUG __STM_EVAL __DBG_ITM
  c include: ..\Library;.\SRC
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
