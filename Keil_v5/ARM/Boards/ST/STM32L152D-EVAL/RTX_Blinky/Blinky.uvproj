# Keil uVision project Blinky.uvproj, settings and files
target STM32L152 Flash (ARM-ADS)
  device: STM32L152ZD STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x805FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Blinky
  c flags: Optim=1
  c define: STM32L1XX_HD
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x60000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group StartUp
    ./: startup_stm32l1xx_hd.s system_stm32l1xx.c
  group Configuration
    ./: RTX_Conf_CM.c
  group Source Files
    ./: GLCD_16bitIF_STM32L1xx.c LED.c Blinky.c
  group Documentation
    ./: Abstract.txt
target STM32L152 RAM (ARM-ADS)
  device: STM32L152ZD STMicroelectronics
  cpu: as above
  output: Blinky
  c flags: Optim=1
  c define: STM32L1XX_HD VECT_TAB_SRAM
  library: MicroLIB
  memory RVCT4: ROM 0x20000000 size 0x8000
  memory RVCT9: RAM 0x20008000 size 0x4000
