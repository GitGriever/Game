# Keil uVision project SD_File.uvproj, settings and files
target LPC1788_USB1 (ARM-ADS)
  device: LPC1788 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x1000FFFF) IRAM2(0x20000000-0x20007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: SD_File
  c flags: Optim=4
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x8000
  group Startup Code
    ./: startup_LPC177x_8x.s system_LPC177x_8x.c
  group Configuration
    ./: File_Config.c usb_config.c
  group Drivers
    ./: KBD.c Serial.c I2C.c MCI_LPC177x_8x.c
  group File System
    ./: Retarget.c
    C:/Keil/ARM/RV31/LIB/: FS_CM3.lib
  group USB
    C:/Keil/ARM/RV31/LIB/: USB_CM3.lib
    ./: usbd_LPC177x_8x.c usbd_user_msc.c
  group Main Code
    ./: Getline.c SD_File.c Memory.c
  group Documentation
    ./: Abstract.txt
target LPC1788_USB2 (ARM-ADS)
  device: LPC1788 NXP (founded by Philips)
  cpu: as above
  output: SD_File
  c flags: Optim=4
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x8000
