# Keil uVision project Memory.uvproj, settings and files
target LPC4330_USB0 SPIFI (ARM-ADS)
  device: LPC4330 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x1001FFFF) IRAM2(0x20000000-0x2000FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") FPU2
  output: Memory
  c flags: Optim=4
  c define: LPC4330_XPLORER
  asm define: NO_CRP
  memory RVCT1: ROM 0x14000000 size 0x400000
  memory RVCT9: RAM 0x10000000 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x10000
  group Startup Code
    ./: startup_LPC43xx.s system_LPC43xx.c
  group Configuration
    ./: File_Config.c usb_config_USB0.c usb_config_USB1.c
  group Drivers
    ./: SDIO_LPC43xx.c LED.c
  group File System
    C:/Keil/ARM/RV31/LIB/: FS_CM3.lib
  group USB
    C:/Keil/ARM/RV31/LIB/: USB_CM3.lib
    ./: usbd_LPC43xx_USB0.c usbd_LPC43xx_USB1.c usbd_user_msc.c
  group Main Code
    ./: Memory.c
  group Documentation
    ./: Abstract.txt
target LPC4330_USB0 RAM (ARM-ADS)
  device: LPC4330 NXP (founded by Philips)
  cpu: as above
  output: Memory
  c flags: Optim=4
  c define: LPC4330_XPLORER
  asm define: NO_CRP
  memory RVCT4: ROM 0x10000000 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x10000
target LPC4330_USB1 SPIFI (ARM-ADS)
  device: LPC4330 NXP (founded by Philips)
  cpu: as above
  output: Memory
  c flags: Optim=4
  c define: LPC4330_XPLORER
  asm define: NO_CRP
  memory RVCT1: ROM 0x14000000 size 0x400000
  memory RVCT9: RAM 0x10000000 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x10000
target LPC4330_USB1 RAM (ARM-ADS)
  device: LPC4330 NXP (founded by Philips)
  cpu: as above
  output: Memory
  c flags: Optim=4
  c define: LPC4330_XPLORER
  asm define: NO_CRP
  memory RVCT4: ROM 0x10000000 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x10000
