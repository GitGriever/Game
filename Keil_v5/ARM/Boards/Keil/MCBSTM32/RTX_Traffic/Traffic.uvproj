# Keil uVision project Traffic.uvproj, settings and files
target Simulator (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Traffic
  c flags: Optim=1
  c define: STM32F10X_MD __USART1
  c include: .
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group StartUp
    ./: startup_stm32f10x_md.s system_stm32f10x.c
  group RTX Configuration
    ./: RTX_Conf_CM.c
  group Source Files
    ./: LCD_4bit.c Retarget.c Serial.c LED.c Getline.c Traffic.c
  group Documentation
    ./: Abstract.txt
target STM32F103 Flash (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: as above
  output: Traffic
  c flags: Optim=4
  c define: STM32F10X_MD __USART1
  c include: .
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target STM32F103 RAM (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: as above
  output: Traffic
  c flags: Optim=4
  c define: STM32F10X_MD VECT_TAB_SRAM __USART1
  c include: .
  library: MicroLIB
  memory RVCT4: ROM 0x20000000 size 0x2800
  memory RVCT9: RAM 0x20002800 size 0x2800
