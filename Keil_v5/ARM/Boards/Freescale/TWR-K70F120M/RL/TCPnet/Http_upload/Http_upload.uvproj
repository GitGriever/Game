# Keil uVision project Http_upload.uvproj, settings and files
target MK70F120M (ARM-ADS)
  device: MK70FN1M0xxx12 Freescale Semiconductor
  cpu: IRAM(0x1FFF0000-0x1FFFFFFF) IRAM2(0x20000000-0x2000FFFF) IROM(0x0-0xFFFFF) CLOCK(12000000) CPUTYPE("Cortex-M4")  FPU2 ELITTLE
  output: Http_upload
  c flags: Optim=4
  c include: ..\Library
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x10000
  group HTTP Files
    ./Web/: Web.inp index.htm upload.cgi dir.cgi format.cgi pg_footer.inc pg_header.inc
  group Source Files
    ./: HTTP_upload.c HTTP_CGI.c
    ./Web/: WEB.C
  group Configuration Files
    ./: Net_Config.c File_Config.c HTTP_uif.c Retarget.c startup_MK70F12.s
  group Library
    C:/Keil/ARM/RV31/LIB/: TCP_CM3.lib FS_CM3.lib
    ../Library/: system_MK70F12.c ENET_MK70.c SDHC_MK70.c LED.c
  group Documentation
    ./: Abstract.txt
