# Keil uVision project HID.uvproj, settings and files
target KL25Z48M (ARM-ADS)
  device: MKL25Z128xxx4 Freescale Semiconductor
  cpu: IRAM(0x1FFFF000-0x1FFFFFFF) IRAM2(0x20000000-0x20002FFF) IROM(0x0-0x1FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0+") ELITTLE
  output: HID
  c flags: Optim=4
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1ffff000 size 0x1000
  memory RVCT10: RAM 0x20000000 size 0x3000
  group Startup Files
    ./: startup_MKL25Z4.s system_MKL25Z4.c
  group Configuration
    ./: usb_config.c
  group USB HW Driver
    ./: usbd_MKL25Z4.c
  group Source
    ./: USBD_Demo.c usbd_user_hid.c KBD.c LED.c
  group Library
    C:/Keil/ARM/RV31/LIB/: USB_CM1.lib
  group Documentation
    ./: Abstract.txt
