# Keil uVision project NAND_File.uvproj, settings and files
target MK60FN1M Flash (ARM-ADS)
  device: MK60FN1M0xxx12 Freescale Semiconductor
  cpu: IRAM(0x1FFF0000-0x1FFFFFFF) IRAM2(0x20000000-0x2000FFFF) IROM(0x0-0xFFFFF) CLOCK(12000000) CPUTYPE("Cortex-M4")  FPU2 ELITTLE
  output: NAND_File
  c flags: Optim=4 wLevel=2
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x10000
  group Source Files
    ./: Getline.c NAND_File.c
  group Configuration Files
    ./: File_Config.c startup_MK60F12.s system_MK60F12.c NAND_MK60.c
  group Com Port
    ./: SER.c Retarget.c
  group Library
    C:/Keil/ARM/RV31/LIB/: FS_CM3.lib
  group Documentation
    ./: Abstract.txt
