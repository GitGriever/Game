# Keil uVision project SN32F710.uvproj, settings and files
target SN32F710_16 USER_ROM (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: SN32F710_16 +hex
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=3
  c define: USER_ROM
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
  group Program Functions
    ./: FlashPrg.c F710_FlashCtrl.lib
  group Device Description
    ./: FlashDev.c
