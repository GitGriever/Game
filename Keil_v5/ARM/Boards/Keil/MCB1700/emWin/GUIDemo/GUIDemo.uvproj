# Keil uVision project GUIDemo.uvproj, settings and files
target MCB1700 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: GUIDemo
  c flags: Optim=4 v6Lang=1 v6LangP=1
  c define: GUI_BYTESPERPIXEL=4 SHOW_GUIDEMO_BITMAP SHOW_GUIDEMO_COLORBAR SHOW_GUIDEMO_CURSOR  SHOW_GUIDEMO_GRAPH SHOW_GUIDEMO_SPEED SHOW_GUIDEMO_TRANSPARENTDIALOG SHOW_GUIDEMO_TREEVIEW
  c include: C:\Keil\ARM\Segger\emWin\Include
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Startup
    ./: startup_LPC17xx.s system_LPC17xx.c
  group Drivers
    ./: LCDConf.c LCD_X_SPI_LPC1700.c JOY.c
  group GUI Library
    ./: GUIConf.c GUI_X.c
    C:/Keil/ARM/Segger/emWin/Lib/: GUI_CM3.lib
  group Source Code
    ./: main.c
    C:/Keil/ARM/Segger/emWin/Sample/Application/GUIDemo/: GUIDEMO.c GUIDEMO_Bitmap.c GUIDEMO_ColorBar.c GUIDEMO_Conf.c GUIDEMO_Cursor.c GUIDEMO_Graph.c GUIDEMO_Intro.c GUIDEMO_Resource.c GUIDEMO_Speed.c GUIDEMO_Start.c GUIDEMO_TransparentDialog.c GUIDEMO_Treeview.c
  group Documentation
    ./: Abstract.txt
target MCB1700 LCD_LG (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: as above
  output: GUIDemo
  c flags: Optim=4 v6Lang=1 v6LangP=1
  c define: as above
  c include: C:\Keil\ARM\Segger\emWin\Include
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
