# Keil uVision project Blinky.uvproj, settings and files
target SWO Trace (ARM-ADS)
  device: STM32F303VC STMicroelectronics
  cpu: IRAM(0x20000000-0x20009FFF) IRAM2(0x10000000-0x10001FFF) IROM(0x08000000-0x0803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: Blinky
  c flags: Optim=1
  c define: __USE_LCD
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xa000
  memory RVCT10: RAM 0x10000000 size 0x2000
  group StartUp
    ./: startup_stm32f303xc.s system_stm32f3xx.c
  group Source Files
    ./: Retarget.c Serial.c IRQ.c LED.c Blinky.c GLCD_SPI_STM32F30x.c ADC.c
  group Documentation
    ./: Abstract.txt
target TracePort Trace (ARM-ADS)
  device: STM32F303VC STMicroelectronics
  cpu: as above
  output: Blinky
  c flags: Optim=1
  c define: __USE_LCD
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xa000
  memory RVCT10: RAM 0x10000000 size 0x2000
target TracePort IntructionTrace (ARM-ADS)
  device: STM32F303VC STMicroelectronics
  cpu: as above
  output: Blinky
  c flags: Optim=1
  c define: __USE_LCD
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xa000
  memory RVCT10: RAM 0x10000000 size 0x2000
