# Keil uVision project Blinky.uvproj, settings and files
target LM3S6965 (ARM-ADS)
  device: LM3S6965 Luminary Micro
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0-0x3FFFF) CLOCK(6000000) CPUTYPE("Cortex-M3")
  output: Blinky
  c flags: Optim=4
  c define: rvmdk PART_LM3S6965
  c include: C:/Keil/ARM/RV31/LIB/Luminary
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source
    ./: startup_rvmdk_RTX.S Blinky.c
  group Configuration
    ./: RTX_Conf_CM.c
  group Library
    C:/Keil/ARM/RV31/LIB/Luminary/: driverlib-cm3.lib
  group Documentation
    ./: Abstract.txt
