# Keil uVision project GUIDemo.uvproj, settings and files
target MCBSTM32C (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F107VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: GUIDemo
  c flags: Optim=4 v6Lang=1 v6LangP=1
  c define: STM32F10X_CL GUI_BYTESPERPIXEL=4 SHOW_GUIDEMO_COLORBAR SHOW_GUIDEMO_CURSOR  SHOW_GUIDEMO_GRAPH SHOW_GUIDEMO_LISTVIEW SHOW_GUIDEMO_SPEED SHOW_GUIDEMO_TREEVIEW
  c include: C:\Keil\ARM\Segger\emWin\Include
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Startup
    ./: startup_stm32f10x_cl.s system_stm32f10x_cl.c
  group Drivers
    ./: LCDConf.c LCD_X_SPI_STM32.c I2C_STM32.c TSC_STMPE811.c JOY.c
  group GUI Library
    ./: GUIConf.c GUI_X.c
    C:/Keil/ARM/Segger/emWin/Lib/: GUI_CM3.lib
  group Source Code
    ./: main.c
    C:/Keil/ARM/Segger/emWin/Sample/Application/GUIDemo/: GUIDEMO.c GUIDEMO_ColorBar.c GUIDEMO_Conf.c GUIDEMO_Cursor.c GUIDEMO_Graph.c GUIDEMO_Intro.c GUIDEMO_Listview.c GUIDEMO_Resource.c GUIDEMO_Speed.c GUIDEMO_Start.c GUIDEMO_Treeview.c
  group Documentation
    ./: Abstract.txt
target MCBSTM32C LCD_LG (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: as above
  output: GUIDemo
  c flags: Optim=4 v6Lang=1 v6LangP=1
  c define: STM32F10X_CL GUI_BYTESPERPIXEL=4 SHOW_GUIDEMO_AUTOMOTIVE SHOW_GUIDEMO_COLORBAR SHOW_GUIDEMO_CURSOR  SHOW_GUIDEMO_GRAPH SHOW_GUIDEMO_LISTVIEW SHOW_GUIDEMO_SPEED SHOW_GUIDEMO_TREEVIEW
  c include: C:\Keil\ARM\Segger\emWin\Include
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
