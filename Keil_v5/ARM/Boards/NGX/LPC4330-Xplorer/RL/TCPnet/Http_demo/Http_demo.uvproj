# Keil uVision project Http_demo.uvproj, settings and files
target LPC4330 (ARM-ADS)
  device: LPC4330 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x1001FFFF) IRAM2(0x20000000-0x2000FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") FPU2
  output: Http_demo
  c flags: Optim=1
  c define: LPC4330_XPLORER
  c include: ..\Library
  asm define: NO_CRP
  library: MicroLIB
  memory RVCT1: ROM 0x14000000 size 0x400000
  memory RVCT9: RAM 0x10000000 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x10000
  group HTTP Files
    ./Web/: Web.inp index.htm network.cgi leds.cgi system.cgi tcp.cgi language.cgi buttons.cgi pg_footer.inc pg_header.inc buttons.cgx xml_http.js
  group Source Files
    ./: HTTP_demo.c HTTP_CGI.c
    ./Web/: WEB.C
  group Configuration Files
    ./: Net_Config.c Net_Debug.c RTX_Config.c startup_lpc43xx.s
  group Library
    C:/Keil/ARM/RV31/LIB/: TCP_CM3.lib TCPD_CM3.lib
    ../Library/: ETH_LPC43xx.c system_LPC43xx.c Serial.c LED.c KBD.c
  group Documentation
    ./: Abstract.txt
target LPC4330 Debug (ARM-ADS)
  device: LPC4330 NXP (founded by Philips)
  cpu: as above
  output: Http_demo
  c flags: Optim=1
  c define: LPC4330_XPLORER
  c include: ..\Library
  asm define: NO_CRP
  library: MicroLIB
  memory RVCT4: ROM 0x10000000 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x10000
target LPC4330 RTX (ARM-ADS)
  device: LPC4330 NXP (founded by Philips)
  cpu: as above
  output: Http_demo
  c flags: Optim=1
  c define: LPC4330_XPLORER RTX_KERNEL
  c include: ..\Library
  asm define: NO_CRP
  library: MicroLIB
  memory RVCT1: ROM 0x14000000 size 0x400000
  memory RVCT9: RAM 0x10000000 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x10000
