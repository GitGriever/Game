# Keil uVision project Blinky.uvproj, settings and files
target LPC1857 Flash (ARM-ADS)
  device: LPC1857 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x20000000-0x2000FFFF) IROM(0x1A000000-0x1A07FFFF) IROM2(0x1B000000-0x1B07FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: Blinky_Flash
  AfterMake: $K\ARM\BIN\ElfDwT.exe !L BASEADDRESS(0x1A000000)
  c flags: Optim=1
  asm define: NO_CRP
  library: MicroLIB
  memory RVCT4: ROM 0x1a000000 size 0x80000
  memory RVCT5: ROM 0x1b000000 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x10000
  group Startup Code
    ./: startup_LPC18xx.s system_LPC18xx.c
  group Source
    ./: Blinky.c LED_LPC18xx.c
  group Documentation
    ./: Abstract.txt
target LPC1850 RAM (ARM-ADS)
  device: LPC1850 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10017FFF) IRAM2(0x20000000-0x2000FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: Blinky_RAM
  c flags: Optim=4
  asm define: NO_CRP
  library: MicroLIB
  memory RVCT4: ROM 0x10000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x10000
target LPC1850 Ext. Flash (ARM-ADS)
  device: LPC1850 NXP (founded by Philips)
  cpu: as above
  output: Blinky_Flash
  c flags: Optim=1
  asm define: NO_CRP
  library: MicroLIB
  memory RVCT1: ROM 0x1c000000 size 0x1000000
  memory RVCT9: RAM 0x10000000 size 0x18000
  memory RVCT10: RAM 0x20000000 size 0x10000
target LPC1850 SPIFI (ARM-ADS)
  device: LPC1850 NXP (founded by Philips)
  cpu: as above
  output: Blinky_SPIFI
  c flags: Optim=1
  asm define: NO_CRP
  library: MicroLIB
  memory RVCT1: ROM 0x14000000 size 0x400000
  memory RVCT9: RAM 0x10000000 size 0x18000
  memory RVCT10: RAM 0x20000000 size 0x10000
