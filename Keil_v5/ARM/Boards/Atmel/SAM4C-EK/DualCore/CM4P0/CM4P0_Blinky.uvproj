# Keil uVision project CM4P0_Blinky.uvproj, settings and files
target SAM4C_CM4P0 RAM (ARM-ADS)
  device: SAM4C16C CM4P0 Atmel
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x1000000-0x10FFFFF) CLOCK(12000000) CPUTYPE("Cortex-M4")
  output: CM4P0_Blinky
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x20000000 size 0x10000
  memory RVCT9: RAM 0x20010000 size 0x10000
  group StartUp
    ./: startup_SAM4C.s system_SAM4C.c
  group CM4P1 Image
    ./: CM4P1_Image.c
  group Source Files
    ./: LED.c CM4P0_Blinky.c
  group Documentation
    ./: Abstract.txt
target SAM4C_CM4P0 Flash (ARM-ADS)
  device: SAM4C16C CM4P0 Atmel
  cpu: as above
  output: CM4P0_Blinky
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x1000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
