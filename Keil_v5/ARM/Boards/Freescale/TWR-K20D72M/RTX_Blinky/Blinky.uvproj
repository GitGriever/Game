# Keil uVision project Blinky.uvproj, settings and files
target ULink - Flash (ARM-ADS)
  device: MK20DX256xxx7 Freescale Semiconductor
  cpu: IRAM(0x1FFF8000-0x1FFFFFFF) IRAM2(0x20000000-0x20007FFF) IROM(0x0-0x3FFFF) IROM2(0x10000000-0x10007FFF) CLOCK(12000000) CPUTYPE("Cortex-M4") ELITTLE
  output: Blinky
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x10000000 size 0x8000
  memory RVCT9: RAM 0x1fff8000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x8000
  group Startup
    ./: startup_MK20D7.s system_MK20D7.c
  group Source Files
    ./: Blinky.c
  group RTX Configuration
    ./: RTX_Conf_CM.c
  group Documentation
    ./: Abstract.txt
target ULink - RAM (ARM-ADS)
  device: MK20DX256xxx7 Freescale Semiconductor
  cpu: as above
  output: Blinky
  c flags: Optim=1
  memory RVCT4: ROM 0x1fff8000 size 0x8000
  memory RVCT5: ROM 0x10000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x8000
target ULinkPro - Flash (ARM-ADS)
  device: MK20DX256xxx7 Freescale Semiconductor
  cpu: as above
  output: Blinky
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x10000000 size 0x8000
  memory RVCT9: RAM 0x1fff8000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x8000
target ULinkPro - RAM (ARM-ADS)
  device: MK20DX256xxx7 Freescale Semiconductor
  cpu: as above
  output: Blinky
  c flags: Optim=1
  memory RVCT4: ROM 0x1fff8000 size 0x8000
  memory RVCT5: ROM 0x10000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x8000
target PE OSJTAG-Flash (ARM-ADS)
  device: MK20DX256xxx7 Freescale Semiconductor
  cpu: as above
  output: Blinky
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x10000000 size 0x8000
  memory RVCT9: RAM 0x1fff8000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x8000
target PE OSJTAG-RAM (ARM-ADS)
  device: MK20DX256xxx7 Freescale Semiconductor
  cpu: as above
  output: Blinky
  c flags: Optim=1
  memory RVCT4: ROM 0x1fff8000 size 0x8000
  memory RVCT5: ROM 0x10000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x8000
