# Keil uVision project VirtualCOM.uvproj, settings and files
target MCBSTM32C (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: VirtualCOM
  c flags: Optim=4
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Startup Files
    ./: startup_stm32f10x_cl.s system_stm32f10x_cl.c
    ./: SVC_Table.s
  group Configuration
    ./: RTX_Conf_CM.c usb_config.c
  group USB HW Driver
    ./: usbd_STM32F10x_cl.c
  group Source
    ./: USBD_Demo.c UART_STM32fF0x_CL.c
    ./: GLCD_SPI_STM32.c LED_MCBSTM32C.c usbd_user_cdc_acm.c
  group Library
    C:/Keil/ARM/RV31/LIB/: USB_CM3.lib
  group Documentation
    ./: Abstract.txt
