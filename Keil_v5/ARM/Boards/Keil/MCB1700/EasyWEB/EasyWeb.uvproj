# Keil uVision project EasyWeb.uvproj, settings and files
target LPC1768 Flash (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: EasyWeb
  c flags: Optim=1
  c define: __FLASH
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group HTML Source
    ./: webpage.html
  group StartUp
    ./: startup_LPC17xx.s system_LPC17xx.c
  group Configuration
    ./: tcpip.h
  group EasyWeb
    ./: Retarget.c EMAC.c tcpip.c easyweb.c
  group Documentation
    ./: Abstract.txt
target LPC1758 Flash (ARM-ADS)
  device: LPC1758 NXP (founded by Philips)
  cpu: as above
  output: EasyWeb
  c flags: Optim=1
  c define: __FLASH
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
