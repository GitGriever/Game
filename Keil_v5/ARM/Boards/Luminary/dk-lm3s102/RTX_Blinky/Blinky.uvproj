# Keil uVision project Blinky.uvproj, settings and files
target Simulator (ARM-ADS)
  device: LM3S102 Luminary Micro
  cpu: IRAM(0x20000000-0x200007FF) IROM(0-0x1FFF) CLOCK(20000000) CPUTYPE("Cortex-M3")
  output: Blinky
  c flags: Optim=4
  c define: rvmdk PART_LM3S102
  c include: C:/Keil/ARM/RV31/LIB/Luminary
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x2000
  memory RVCT9: RAM 0x20000000 size 0x800
  group Source
    ./: Blinky.c
  group Configuration
    ./: startup_rvmdk_RTX.S RTX_Conf_CM.c
  group Library
    C:/Keil/ARM/RV31/LIB/Luminary/: driverlib-cm3.lib
  group Documentation
    ./: Abstract.txt
target LM3S102 (ARM-ADS)
  device: LM3S102 Luminary Micro
  cpu: as above
  output: Blinky
  c flags: Optim=4
  c define: rvmdk PART_LM3S102
  c include: C:/Keil/ARM/RV31/LIB/Luminary
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x2000
  memory RVCT9: RAM 0x20000000 size 0x800
