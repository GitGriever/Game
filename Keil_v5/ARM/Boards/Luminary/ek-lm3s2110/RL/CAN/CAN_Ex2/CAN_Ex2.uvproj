# Keil uVision project CAN_Ex2.uvproj, settings and files
target LM3S2110 Flash (ARM-ADS)
  device: LM3S2110 Luminary Micro
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0xFFFF) CLOCK(6000000) CPUTYPE("Cortex-M3")
  output: CAN_Ex2
  c flags: Optim=1
  c define: rvmdk PART_LM3S2110
  c misc: --diag_suppress 3419
  c include: .\; C:/Keil/ARM/RV31/LIB/Luminary
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Configuration
    ./: startup_rvmdk.S RTX_Conf_CM.c
  group CAN Core
    ./: CAN_Cfg.h
    C:/Keil/ARM/RL/CAN/SRC/: RTX_CAN.c
  group CAN Driver
    ./: CAN_LM3Sxxxx.c
  group Source
    ./: CAN_Ex2.c
  group Library
    C:/Keil/ARM/RV31/LIB/Luminary/: driverlib-cm3.lib
  group Documentation
    ./: Abstract.txt
