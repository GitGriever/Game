# Keil uVision project Blinky.uvproj, settings and files
target LPC11U14 Flash (ARM-ADS)
  device: LPC11U14/201 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10000FFF) IROM(0-0x7FFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: Blinky
  c flags: Optim=1
  c define: __ADC_IRQ
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x1000
  group StartUp
    ./: startup_LPC11Uxx.s system_LPC11Uxx.c
  group Source Files
    ./: Retarget.c Serial.c LED.c ADC.c IRQ.c Blinky.c
  group Documentation
    ./: Abstract.txt
target LPC11U14 RAM (ARM-ADS)
  device: LPC11U14/201 NXP (founded by Philips)
  cpu: as above
  output: Blinky
  c flags: Optim=1
  c define: __ADC_IRQ
  library: MicroLIB
  memory RVCT4: ROM 0x10000000 size 0xe40
  memory RVCT9: RAM 0x10000e40 size 0x1a0
