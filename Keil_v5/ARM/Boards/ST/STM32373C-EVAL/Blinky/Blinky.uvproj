# Keil uVision project Blinky.uvproj, settings and files
target STM32F373 Flash (ARM-ADS)
  device: STM32F373VC STMicroelectronics
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x08000000-0x0803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: Blinky
  c flags: Optim=1
  c define: __USE_LCD
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group StartUp
    ./: startup_stm32f373xc.s system_stm32f3xx.c
  group Source Files
    ./: GLCD_SPI_STM32F37x.c Retarget.c Serial.c SDADC.c LED.c IRQ.c Blinky.c
  group Documentation
    ./: Abstract.txt
target STM32F373 RAM (ARM-ADS)
  device: STM32F373VC STMicroelectronics
  cpu: as above
  output: Blinky
  c flags: Optim=1
  c define: __USE_LCD VECT_TAB_SRAM
  library: MicroLIB
  memory RVCT4: ROM 0x20000000 size 0x4000
  memory RVCT9: RAM 0x20004000 size 0x4000
