# Keil uVision project FTP_client.uvproj, settings and files
target MCBSTM32C (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: FTP_client
  c flags: Optim=4
  c include: ..\Library
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source Files
    ./: FTP_client.c FTPC_uif.c
  group Configuration Files
    ./: Net_Config.c Net_Debug.c File_Config.c Retarget.c startup_stm32f10x_cl.s
  group Library
    C:/Keil/ARM/RV31/LIB/: TCP_CM3.lib TCPD_CM3.lib FS_CM3.lib
    ../Library/: ETH_STM32x.c SPI_STM32F107.c GLCD_SPI_STM32.c system_stm32f10x_cl.c
  group Documentation
    ./: Abstract.txt
target MCBSTM32C Debug (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: as above
  output: FTP_client
  c flags: Optim=4
  c include: ..\Library
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
