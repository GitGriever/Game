# Keil uVision project Measure.uvproj, settings and files
target MCBSTM32C (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: Measure
  c flags: Optim=4
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group StartUp
    ./: startup_stm32f10x_cl.s system_stm32f10x_cl.c
  group Source
    ./: GLCD_SPI_STM32.c Retarget.c Serial.c Getline.c Mcommand.c Measure.c
  group Documentation
    ./: Abstract.txt
