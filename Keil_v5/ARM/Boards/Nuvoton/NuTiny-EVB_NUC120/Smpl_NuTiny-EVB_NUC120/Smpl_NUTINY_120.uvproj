# Keil uVision project Smpl_NUTINY_120.uvproj, settings and files
target Smpl_NUTINY_100 (ARM-ADS)
  device: NUC120LE3AN Nuvoton
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x1FFFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: Smpl_NUTINY_100
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=1 OneElfS=1
  c include: ..\Include\Driver
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --map --first='startup_NUC1xx.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS files
    ./: system_NUC1xx.c startup_NUC1xx.s
  group Source files
    ./: Smpl_NUTINY_120.c
  group Library files
    ../Src/Driver/: DrvGPIO.c DrvUART.c DrvSYS.c retarget.c
  group Documentation
    ./: Abstract.txt
