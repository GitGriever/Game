# Keil uVision project Memory.uvproj, settings and files
target STM32F103 Flash (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Memory
  c flags: Optim=1
  c define: STM32F10X_HD
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group StartUp
    ./: startup_stm32f10x_hd.s system_stm32f10x.c
  group USB Configuration
    ./: usbcfg_STM32F10x.h
  group Disk Image
    ./: DiskImg.c
  group Source Code
    ./: usbhw_STM32F10x.c usbcore.c usbdesc.c usbuser.c mscuser.c memory.c
  group Documentation
    ./: Abstract.txt
