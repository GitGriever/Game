# Keil uVision project CAN_Ex1.uvproj, settings and files
target STM32F207 Flash (ARM-ADS)
  device: STM32F207IG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: CAN_Ex1
  c flags: Optim=4
  c include: .\
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group StartUp
    ./: startup_stm32f2xx.s system_stm32f2xx.c
  group Configuration
    ./: RTX_Conf_CM.c
  group CAN Core
    ./: CAN_Cfg.h
    C:/Keil/ARM/RL/CAN/SRC/: RTX_CAN.c
  group CAN Driver
    ./: CAN_STM32F20x.c
  group Source
    ./: CAN_Ex1.c
  group Driver
    ./: ADC.c GLCD_16bitIF_STM32F2xx.c
  group Documentation
    ./: Abstract.txt
