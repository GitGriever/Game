# Keil uVision project CAN_Ex2.uvproj, settings and files
target K60N512 (ARM-ADS)
  device: MK60N512VMD100 Freescale Semiconductor
  cpu: IRAM(0x1FFF0000-0x1FFFFFFF) IRAM2(0x20000000-0x2000FFFF) IROM(0x0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") ELITTLE
  output: CAN_Ex2
  c flags: Optim=4
  c include: .\
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x10000
  group StartUp
    ./: startup_MK60N512MD100.s system_MK60N512MD100.c
  group RTX Configuration
    ./: RTX_Config.c
  group CAN Core
    ./: CAN_Cfg.h
    C:/Keil/ARM/RL/CAN/SRC/: RTX_CAN.c
  group CAN Driver
    ./: CAN_MK60.c
  group Source
    ./: CAN_Ex2.c ADC.c LED.c
  group Documentation
    ./: Abstract.txt
