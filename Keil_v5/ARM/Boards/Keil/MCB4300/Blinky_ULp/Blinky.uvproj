# Keil uVision project Blinky.uvproj, settings and files
target ExtFlash SWO Trace (ARM-ADS)
  device: LPC4350 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x1001FFFF) IRAM2(0x20000000-0x2000FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") FPU2
  output: Blinky
  c flags: Optim=1
  library: MicroLIB
  memory RVCT1: ROM 0x1c000000 size 0x1000000
  memory RVCT9: RAM 0x10000000 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x10000
  group StartUp
    ./: startup_LPC43xx.s system_LPC43xx.c
  group Source Files
    ./: Retarget.c ADC_LPC43xx.c Serial_LPC43xx.c LED_LPC43xx.c IRQ.c Blinky.c
  group Trace Configuration
    ./: LPC43xx_TP.ini
  group Documentation
    ./: Abstract.txt
target ExtFlash TracePort Trace (ARM-ADS)
  device: LPC4350 NXP (founded by Philips)
  cpu: as above
  output: Blinky
  c flags: Optim=1
  library: MicroLIB
  memory RVCT1: ROM 0x1c000000 size 0x1000000
  memory RVCT9: RAM 0x10000000 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x10000
target ExtFlash TracePort Instruction Trace (ARM-ADS)
  device: LPC4350 NXP (founded by Philips)
  cpu: as above
  output: Blinky
  c flags: Optim=1
  library: MicroLIB
  memory RVCT1: ROM 0x1c000000 size 0x1000000
  memory RVCT9: RAM 0x10000000 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x10000
target ExtFlash Embedded Trace Buffer (ARM-ADS)
  device: LPC4350 NXP (founded by Philips)
  cpu: as above
  output: Blinky
  c flags: Optim=1
  library: MicroLIB
  memory RVCT1: ROM 0x1c000000 size 0x1000000
  memory RVCT9: RAM 0x10000000 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x10000
target Flash SWO Trace (ARM-ADS)
  device: LPC4357 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x20000000-0x2000FFFF) IROM(0x1A000000-0x1A07FFFF) IROM2(0x1B000000-0x1B07FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") FPU2
  output: Blinky
  AfterMake: $K\ARM\BIN\ElfDwT.exe !L BASEADDRESS(0x1A000000)
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x1a000000 size 0x80000
  memory RVCT5: ROM 0x1b000000 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x10000
target Flash TracePortTrace (ARM-ADS)
  device: LPC4357 NXP (founded by Philips)
  cpu: as above
  output: Blinky
  AfterMake: $K\ARM\BIN\ElfDwT.exe !L BASEADDRESS(0x1A000000)
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x1a000000 size 0x80000
  memory RVCT5: ROM 0x1b000000 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x10000
target Flash TracePort Instruction Trace (ARM-ADS)
  device: LPC4357 NXP (founded by Philips)
  cpu: as above
  output: Blinky
  AfterMake: $K\ARM\BIN\ElfDwT.exe !L BASEADDRESS(0x1A000000)
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x1a000000 size 0x80000
  memory RVCT5: ROM 0x1b000000 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x10000
target Flash Embedded Trace Buffer (ARM-ADS)
  device: LPC4357 NXP (founded by Philips)
  cpu: as above
  output: Blinky
  AfterMake: $K\ARM\BIN\ElfDwT.exe !L BASEADDRESS(0x1A000000)
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x1a000000 size 0x80000
  memory RVCT5: ROM 0x1b000000 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x10000
