# Keil uVision project Blinky.uvproj, settings and files
target STM32100E-EVAL Flash (ARM-ADS)
  device: STM32F100ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Blinky
  c flags: Optim=1
  c define: STM32F10X_HD_VL __USE_LCD
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group StartUp
    ./: startup_stm32f10x_hd_vl.s system_stm32f10x.c
  group Source Files
    ./: Blinky.c IRQ.c Retarget.c Serial.c GLCD_16bitIF_STM32.c
  group Documentation
    ./: Abstract.txt
target STM32100E-EVAL RAM (ARM-ADS)
  device: STM32F100ZE STMicroelectronics
  cpu: as above
  output: Blinky
  c flags: Optim=1
  c define: STM32F10X_HD_VL VECT_TAB_SRAM __USE_LCD
  library: MicroLIB
  memory RVCT4: ROM 0x20000000 size 0x4000
  memory RVCT9: RAM 0x20004000 size 0x4000
target STM32100E_EVAL Trace (ARM-ADS)
  device: STM32F100ZE STMicroelectronics
  cpu: as above
  output: Blinky
  c flags: Optim=1
  c define: STM32F10X_HD_VL __USE_LCD
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x8000
