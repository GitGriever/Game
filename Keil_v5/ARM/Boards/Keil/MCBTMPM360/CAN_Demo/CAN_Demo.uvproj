# Keil uVision project CAN_Demo.uvproj, settings and files
target TMPM364 Flash (ARM-ADS)
  device: TMPM364F10FG Toshiba
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0-0x0FFFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: CAN_Demo
  c flags: Optim=4
  c include: .\
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Startup Code
    ./: startup_TMPM364.s system_TMPM364.c
  group CAN Driver
    ./: CAN_tmpm364.c
  group Source
    ./: CAN_Demo.c BTN.c LED.c ADC.c
  group Documentation
    ./: Abstract.txt
target TMPM364 RAM (ARM-ADS)
  device: TMPM364F10FG Toshiba
  cpu: as above
  output: CAN_Demo
  c flags: Optim=4
  c include: .\
  library: MicroLIB
  memory RVCT4: ROM 0x20000000 size 0x8000
  memory RVCT9: RAM 0x20008000 size 0x8000
