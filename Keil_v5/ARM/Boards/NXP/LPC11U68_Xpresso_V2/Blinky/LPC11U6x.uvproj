# Keil uVision project LPC11U6x.uvproj, settings and files
target LPC11U68 RAM (ARM-ADS)
  device: LPC11U68 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x20000000-0x200007FF) IROM(0x0-0x3FFFF) CLOCK(12000000) CPUTYPE("Cortex-M0+")
  output: LPC11U6x
  c flags: Optim=1
  memory RVCT4: ROM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x800
  group StartUp
    ./: startup_LPC11U6x.s system_LPC11U6x.c
  group Source Files
    ./: LED.c Blinky.c
  group Documentation
    ./: Abstract.txt
target LPC11U68 Flash (ARM-ADS)
  device: LPC11U68 NXP (founded by Philips)
  cpu: as above
  output: LPC11U6x
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x800
