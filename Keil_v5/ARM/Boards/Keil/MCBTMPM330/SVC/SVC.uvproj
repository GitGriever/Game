# Keil uVision project SVC.uvproj, settings and files
target Simulator (ARM-ADS)
  device: TMPM330FDFG Toshiba
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x7FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: SVC
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group System Files
    ./: startup_TMPM330.s system_TMPM330.c
  group Source Files
    ./: SVC.c Test.c
  group Documentation
    ./: Abstract.txt
target TMPM330 Flash (ARM-ADS)
  device: TMPM330FDFG Toshiba
  cpu: as above
  output: SVC
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x8000
target TMPM330 RAM (ARM-ADS)
  device: TMPM330FDFG Toshiba
  cpu: as above
  output: SVC
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x20000000 size 0x4000
  memory RVCT9: RAM 0x20004000 size 0x4000
