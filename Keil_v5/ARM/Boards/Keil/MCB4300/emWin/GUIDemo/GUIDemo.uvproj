# Keil uVision project GUIDemo.uvproj, settings and files
target LPC4350 Ext. Flash (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: LPC4350 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x1001FFFF) IRAM2(0x20000000-0x2000FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") FPU2
  output: GUIDemo
  c flags: Optim=4 v6Lang=1 v6LangP=1
  c define: JOYSTICK_ROTATE GUI_BYTESPERPIXEL=4 SHOW_GUIDEMO_AUTOMOTIVE SHOW_GUIDEMO_BARGRAPH SHOW_GUIDEMO_BITMAP SHOW_GUIDEMO_COLORBAR SHOW_GUIDEMO_CURSOR  SHOW_GUIDEMO_FADING SHOW_GUIDEMO_GRAPH SHOW_GUIDEMO_ICONVIEW SHOW_GUIDEMO_LISTVIEW SHOW_GUIDEMO_SKINNING SHOW_GUIDEMO_SPEED SHOW_GUIDEMO_TRANSPARENTDIALOG SHOW_GUIDEMO_TREEVIEW SHOW_GUIDEMO_WASHINGMACHINE
  c include: C:\Keil\ARM\Segger\emWin\Include
  memory RVCT1: ROM 0x1c000000 size 0x1000000
  memory RVCT6: RAM 0x28100000 size 0x300000
  memory RVCT7: RAM 0x28400000 size 0xc00000
  memory RVCT9: RAM 0x10000000 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x10000
  group Startup
    ./: startup_LPC43xx.s system_LPC43xx.c
  group Drivers
    ./: LCDConf.c LCD_X_LPC4300.c I2C_LPC43xx.c TSC_STMPE811.c JOY_LPC43xx.c
  group GUI Library
    ./: GUIConf.c GUI_X.c
    C:/Keil/ARM/Segger/emWin/Lib/: GUI_CM3.lib
  group Source Code
    ./: main.c
    C:/Keil/ARM/Segger/emWin/Sample/Application/GUIDemo/: GUIDEMO.c GUIDEMO_Automotive.c GUIDEMO_BarGraph.c GUIDEMO_Bitmap.c GUIDEMO_ColorBar.c GUIDEMO_Conf.c GUIDEMO_Cursor.c GUIDEMO_Fading.c GUIDEMO_Graph.c GUIDEMO_IconView.c GUIDEMO_Intro.c GUIDEMO_Listview.c GUIDEMO_Resource.c GUIDEMO_Skinning.c GUIDEMO_Speed.c GUIDEMO_Start.c GUIDEMO_TransparentDialog.c GUIDEMO_Treeview.c GUIDEMO_WashingMachine.c
  group Documentation
    ./: Abstract.txt
target LPC4357 Flash (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: LPC4357 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x20000000-0x2000FFFF) IROM(0x1A000000-0x1A07FFFF) IROM2(0x1B000000-0x1B07FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") FPU2
  output: GUIDemo
  AfterMake: $K\ARM\BIN\ElfDwT.exe !L BASEADDRESS(0x1A000000)
  c flags: Optim=4 v6Lang=1 v6LangP=1
  c define: as above
  c include: C:\Keil\ARM\Segger\emWin\Include
  memory RVCT4: ROM 0x1a000000 size 0x80000
  memory RVCT5: ROM 0x1b000000 size 0x80000
  memory RVCT6: RAM 0x28100000 size 0x300000
  memory RVCT7: RAM 0x28400000 size 0xc00000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x10000
