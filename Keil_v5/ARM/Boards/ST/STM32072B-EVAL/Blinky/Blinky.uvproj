# Keil uVision project Blinky.uvproj, settings and files
target STM32F072 RAM (ARM-ADS)
  device: STM32F072RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0x08000000-0x0801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: Blinky
  c flags: Optim=1
  c define: __USE_LCD
  library: MicroLIB
  memory RVCT4: ROM 0x20000000 size 0x3800
  memory RVCT9: RAM 0x20003800 size 0x800
  group StartUp
    ./: startup_stm32f072.s system_stm32f0xx.c
  group Source Files
    ./: Serial.c Retarget.c LED.c IRQ.c GLCD_SPI_STM32F0xx.c Blinky.c ADC.c
  group Documentation
    ./: Abstract.txt
target STM32F072 Flash (ARM-ADS)
  device: STM32F072RB STMicroelectronics
  cpu: as above
  output: Blinky
  c flags: Optim=1
  c define: __USE_LCD
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
