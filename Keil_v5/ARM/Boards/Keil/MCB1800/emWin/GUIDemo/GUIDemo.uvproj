# Keil uVision project GUIDemo.uvproj, settings and files
target LPC1800 Ext. Flash (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: LPC1850 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10017FFF) IRAM2(0x20000000-0x2000FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: GUIDemo
  c flags: Optim=4 v6Lang=1 v6LangP=1
  c define: JOYSTICK_ROTATE GUI_BYTESPERPIXEL=4 SHOW_GUIDEMO_AUTOMOTIVE SHOW_GUIDEMO_BARGRAPH SHOW_GUIDEMO_BITMAP SHOW_GUIDEMO_COLORBAR SHOW_GUIDEMO_CURSOR  SHOW_GUIDEMO_FADING SHOW_GUIDEMO_GRAPH SHOW_GUIDEMO_ICONVIEW SHOW_GUIDEMO_LISTVIEW SHOW_GUIDEMO_SKINNING SHOW_GUIDEMO_SPEED SHOW_GUIDEMO_TRANSPARENTDIALOG SHOW_GUIDEMO_TREEVIEW SHOW_GUIDEMO_WASHINGMACHINE
  c include: C:\Keil\ARM\Segger\emWin\Include
  memory RVCT1: ROM 0x1c000000 size 0x100000
  memory RVCT6: RAM 0x28100000 size 0x300000
  memory RVCT7: RAM 0x28400000 size 0xc00000
  memory RVCT9: RAM 0x10000000 size 0x18000
  memory RVCT10: RAM 0x20000000 size 0x10000
  group Startup
    ./: startup_LPC18xx.s system_LPC18xx.c
  group Drivers
    ./: LCDConf.c LCD_X_LPC1800.c I2C_LPC18xx.c TSC_STMPE811.c JOY_LPC18xx.c
  group GUI Library
    ./: GUIConf.c GUI_X.c
    C:/Keil/ARM/Segger/emWin/Lib/: GUI_CM3.lib
  group Source Code
    ./: main.c
    C:/Keil/ARM/Segger/emWin/Sample/Application/GUIDemo/: GUIDEMO.c GUIDEMO_Automotive.c GUIDEMO_BarGraph.c GUIDEMO_Bitmap.c GUIDEMO_ColorBar.c GUIDEMO_Conf.c GUIDEMO_Cursor.c GUIDEMO_Fading.c GUIDEMO_Graph.c GUIDEMO_IconView.c GUIDEMO_Intro.c GUIDEMO_Listview.c GUIDEMO_Resource.c GUIDEMO_Skinning.c GUIDEMO_Speed.c GUIDEMO_Start.c GUIDEMO_TransparentDialog.c GUIDEMO_Treeview.c GUIDEMO_WashingMachine.c
  group Documentation
    ./: Abstract.txt
