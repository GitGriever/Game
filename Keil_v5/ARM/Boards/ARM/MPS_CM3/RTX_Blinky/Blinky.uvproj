# Keil uVision project Blinky.uvproj, settings and files
target MPS CM3 (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: Blinky
  c flags: Optim=4
  library: MicroLIB
  memory RVCT1: ROM 0x0 size 0x4000000
  memory RVCT6: RAM 0x20000000 size 0x400000
  group Startup Code
    ./: startup_MPS_CM3.s
  group System Code
    ./: system_MPS_CM3.c
  group Core Code
    ./: core_cm3.c
  group Configuration
    ./: RTX_Config.c
  group Source
    ./: Blinky.c
  group Documentation
    ./: Abstract.txt
