# Keil uVision project Measure.uvproj, settings and files
target K40X256 (ARM-ADS)
  device: MK40X256VMD100 Freescale Semiconductor
  cpu: IRAM(0x1FFF8000-0x1FFFFFFF) IRAM2(0x20000000-0x20007FFF) IROM(0x0-0x3FFFF) IROM2(0x10000000-0x1003FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") ELITTLE
  output: Measure
  c flags: Optim=4
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x10000000 size 0x40000
  memory RVCT9: RAM 0x1fff8000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x8000
  group Startup
    ./: startup_MK40N512MD100.s system_MK40N512MD100.c
  group Configuration
    ./: usb_config.c
  group Retarget
    ./: Retarget.c
  group Application
    ./: Measure.c Mcommand.c Getline.c usbh_MK40.c Serial.c ADC.c
  group Library
    C:/Keil/ARM/RV31/LIB/: USB_CM3.lib
  group Documentation
    ./: Abstract.txt
