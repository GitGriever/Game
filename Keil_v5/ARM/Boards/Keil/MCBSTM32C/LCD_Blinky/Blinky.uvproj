# Keil uVision project Blinky.uvproj, settings and files
target MCBSTM32C (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: Blinky
  c flags: Optim=4
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Startup Code
    ./: startup_stm32f10x_cl.s
  group System Code
    ./: system_stm32f10x_cl.c
  group Core Code
    ./: core_cm3.c
  group Source
    ./: Blinky.c IRQ.c GLCD_SPI_STM32.c TS_I2C.c I2C_STM32.c
  group Graphic Data
    ./: ARM_Ani_16bpp.c Bg_16bpp_t.c Bg_16bpp_l.c Bg_16bpp_r.c Bg_16bpp_b.c Bulb_16bpp.c Button_16bpp.c Arrows_16bpp_red.c
  group Documentation
    ./: Abstract.txt
