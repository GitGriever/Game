# Keil uVision project Blinky.uvproj, settings and files
target Simulator (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Blinky
  c flags: Optim=1
  c define: STM32F10X_HD __USE_LCD
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group StartUp
    ./: startup_stm32f10x_hd.s system_stm32f10x.c
  group Source Files
    ./: GLCD_16bitIF_STM32.c LED.c ADC.c IRQ.c Serial.c Retarget.c Blinky.c
  group Documentation
    ./: Abstract.txt
target STM32F103 Flash (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: as above
  output: Blinky
  c flags: Optim=1
  c define: STM32F10X_HD __USE_LCD
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
target STM32F103 RAM (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: as above
  output: Blinky
  c flags: Optim=1
  c define: STM32F10X_HD __USE_LCD VECT_TAB_SRAM
  library: MicroLIB
  memory RVCT4: ROM 0x20000000 size 0x8000
  memory RVCT9: RAM 0x20008000 size 0x8000
target STM32F103 Trace (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: as above
  output: Blinky
  c flags: Optim=1
  c define: STM32F10X_HD __USE_LCD
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
