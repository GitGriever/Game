# Keil uVision project SD_File.uvproj, settings and files
target STM3210C (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: SD_File
  c flags: Optim=4
  c define: STM32F10X_CL
  c include: C:\Keil\ARM\INC
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source Files
    ./: SD_File.c Getline.c
  group Configuration Files
    ./: File_Config.c SPI_STM32F107.c startup_stm32f10x_cl.s
  group Com Port
    ./: Serial.c Retarget.c
  group Library
    C:/Keil/ARM/RV31/LIB/: FS_CM3.lib
    ./: GLCD.c system_stm32f10x.c
  group Documentation
    ./: Abstract.txt
