# Keil uVision project Blinky.uvproj, settings and files
target SAM4S Flash (ARM-ADS)
  device: SAM4S16C Atmel
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x400000-0x4FFFFF) CLOCK(12000000) CPUTYPE("Cortex-M4")
  output: Blinky
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x400000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group StartUp
    ./: startup_SAM4S.s system_SAM4S.c
  group Pictures
    ./: ARM_Ani_16bpp.c Bg_16bpp_b.c Bg_16bpp_l.c Bg_16bpp_r.c Bg_16bpp_t.c
  group Source Files
    ./: GLCD_8bitIF_SAM4S.c LED.c IRQ.c Blinky.c
  group Documentation
    ./: Abstract.txt
