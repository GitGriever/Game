# Keil uVision project Memory.uvproj, settings and files
target LPC1788_USB1 RTX (ARM-ADS)
  device: LPC1788 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x1000FFFF) IRAM2(0x20000000-0x20007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: Memory
  c flags: Optim=4
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x8000
  group Startup Files
    ./: startup_LPC177x_8x.s system_LPC177x_8x.c SVC_Table.s
  group Configuration
    ./: usb_config.c RTX_Config.c
  group USB HW Driver
    ./: usbd_LPC177x_8x.c
  group Source
    ./: USBD_Demo.c usbd_user_msc.c DiskImg.c
  group Library
    C:/Keil/ARM/RV31/LIB/: USB_CM3.lib
  group Documentation
    ./: Abstract.txt
target LPC1788_USB2 RTX (ARM-ADS)
  device: LPC1788 NXP (founded by Philips)
  cpu: as above
  output: Memory
  c flags: Optim=4
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x8000
