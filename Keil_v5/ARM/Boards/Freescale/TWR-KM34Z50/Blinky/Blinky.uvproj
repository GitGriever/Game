# Keil uVision project Blinky.uvproj, settings and files
target ULink - Flash (ARM-ADS)
  device: MKM34Z128xxx5 Freescale Semiconductor
  cpu: IRAM(0x1FFFF000-0x1FFFFFFF) IRAM2(0x20000000-0x20002FFF) IROM(0x0-0x1FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0+") ELITTLE
  output: Blinky
  c flags: Optim=1
  c misc: --c99 --diag_suppress=61
  c include: .\driver
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1ffff000 size 0x1000
  memory RVCT10: RAM 0x20000000 size 0x3000
  link misc: --no_remove
  group Startup
    ./: system_MKM34Z5.c startup_MKM34Z5.s
  group Source Files
    ./: Blinky.c
  group Device Driver Files
    ./driver/: LCD.c adc.c gpio.c
  group Documentation
    ./: Abstract.txt
target ULink - RAM (ARM-ADS)
  device: MKM34Z128xxx5 Freescale Semiconductor
  cpu: as above
  output: Blinky
  c flags: Optim=1
  c misc: --c99 --diag_suppress=61
  c include: .\driver
  memory RVCT4: ROM 0x20000000 size 0x3000
  memory RVCT9: RAM 0x1ffff000 size 0x1000
