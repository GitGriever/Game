# Keil uVision project Blinky.uvproj, settings and files
target CMSIS-DAP-MTB (ARM-ADS)
  device: MKL25Z128xxx4 Freescale Semiconductor
  cpu: IRAM(0x1FFFF000-0x1FFFFFFF) IRAM2(0x20000000-0x20002FFF) IROM(0x0-0x1FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0+") ELITTLE
  output: Blinky
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1ffff000 size 0x1000
  group Startup
    ./: system_MKL25Z4.c startup_MKL25Z4.s
  group Source Files
    ./: Blinky.c
  group Documentation
    ./: Abstract.txt
target ULink-MTB (ARM-ADS)
  device: MKL25Z128xxx4 Freescale Semiconductor
  cpu: as above
  output: Blinky
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1ffff000 size 0x1000
target ULinkPro-MTB (ARM-ADS)
  device: MKL25Z128xxx4 Freescale Semiconductor
  cpu: as above
  output: Blinky
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1ffff000 size 0x1000
