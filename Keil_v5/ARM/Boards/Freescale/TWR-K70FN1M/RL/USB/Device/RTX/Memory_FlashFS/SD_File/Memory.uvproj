# Keil uVision project Memory.uvproj, settings and files
target MK70 RTX (ARM-ADS)
  device: MK70FN1M0xxx12 Freescale Semiconductor
  cpu: IRAM(0x1FFF0000-0x1FFFFFFF) IRAM2(0x20000000-0x2000FFFF) IROM(0x0-0xFFFFF) CLOCK(12000000) CPUTYPE("Cortex-M4")  FPU2 ELITTLE
  output: Memory
  c flags: Optim=4
  c include: ..\Library
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x10000
  group Startup Code
    ./: startup_MK70F12.s system_MK70F12.c SVC_Table.s
  group Configuration
    ./: File_Config.c RTX_Conf_CM.c usb_config.c
  group Drivers
    ./: LED.c KBD.c Serial.c SDHC_MK70.c
  group File System
    ./: Retarget.c
    C:/Keil/ARM/RV31/LIB/: FS_CM3.lib
  group USB
    C:/Keil/ARM/RV31/LIB/: USB_CM3.lib
    ./: usbd_user_msc.c usbd_MK70.c
  group Main Code
    ./: Getline.c SD_File.c Memory.c
  group Documentation
    ./: Abstract.txt
