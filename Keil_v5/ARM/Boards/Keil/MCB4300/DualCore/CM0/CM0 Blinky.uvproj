# Keil uVision project CM0 Blinky.uvproj, settings and files
target LPC4350 M0 RAM (ARM-ADS)
  device: LPC4350 CM0 NXP (founded by Philips)
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: CM0_RAM
  AfterMake: fromelf --cadcombined --output="..\CM4\CM0_Image.c" ".\RAM\CM0_RAM.axf"
  c flags: Optim=1
  asm define: NO_CRP
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x8000 size 0x2000
  group Startup Code
    ./: startup_LPC43xx_M0.s
  group Source
    ./: CM0 Blinky.c LED_LPC43xx.c
  group Documentation
    ./: Abstract.txt
target LPC4350 M0 RAM ULp (ARM-ADS)
  device: LPC4350 CM0 NXP (founded by Philips)
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: CM0_RAM
  AfterMake: as above
  c flags: Optim=1
  asm define: NO_CRP
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x8000 size 0x2000
