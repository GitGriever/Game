# Keil uVision project Blinky.uvproj, settings and files
target STM32F100RB Flash (ARM-ADS)
  device: STM32F100RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Blinky
  c flags: Optim=1
  c define: STM32F10X_LD_VL
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Startup
    ./: startup_stm32f10x_ld_vl.s system_stm32f10x.c
  group Source Files
    ./: Blinky.c
  group Documentation
    ./: Abstract.txt
target STM32F100RB RAM (ARM-ADS)
  device: STM32F100RB STMicroelectronics
  cpu: as above
  output: Blinky
  c flags: Optim=1
  c define: STM32F10X_LD_VL VECT_TAB_SRAM
  memory RVCT4: ROM 0x20000000 size 0x1000
  memory RVCT9: RAM 0x20001000 size 0x1000
