# Keil uVision project SD_File.uvproj, settings and files
target SAM4S16C Flash (ARM-ADS)
  device: SAM4S16C Atmel
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x400000-0x4FFFFF) CLOCK(12000000) CPUTYPE("Cortex-M4")
  output: SD_File
  c flags: Optim=4
  memory RVCT4: ROM 0x400000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group StartUp
    ./: startup_SAM4S.s system_SAM4S.c
  group FFS Configuration
    ./: File_Config.c
  group Retarget
    ./: Retarget.c
  group Source Files
    ./: Getline.c SER.c SD_File.c MCI_SAM4S.c
    ./: GLCD_8bitIF_SAM4S.c
  group Library
    C:/Keil/ARM/RV31/LIB/: FS_CM3.lib
  group Documentation
    ./: Abstract.txt
