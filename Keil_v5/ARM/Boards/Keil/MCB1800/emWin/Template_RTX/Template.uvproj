# Keil uVision project Template.uvproj, settings and files
target LPC1800 RAM (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: LPC1850 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10017FFF) IRAM2(0x20000000-0x2000FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: Template
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c include: C:\Keil\ARM\Segger\emWin\Include
  memory RVCT4: ROM 0x10000000 size 0x18000
  memory RVCT10: RAM 0x20000000 size 0x10000
  group Startup
    ./: startup_LPC18xx.s system_LPC18xx.c
  group RTX Configuration
    ./: RTX_Conf_CM.c
  group LCD Driver
    ./: LCDConf.c LCD_X_LPC1800.c
  group GUI Library
    ./: GUIConf.c GUI_X_RTX.c
    C:/Keil/ARM/Segger/emWin/Lib/: GUI_CM3.lib
  group Source Code
    ./: main.c
  group Documentation
    ./: Abstract.txt
target LPC1800 Ext. Flash (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: LPC1850 NXP (founded by Philips)
  cpu: as above
  output: Template
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c include: C:\Keil\ARM\Segger\emWin\Include
  memory RVCT1: ROM 0x1c000000 size 0x100000
  memory RVCT9: RAM 0x10000000 size 0x18000
  memory RVCT10: RAM 0x20000000 size 0x10000
