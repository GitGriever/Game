# Keil uVision project HID.uvproj, settings and files
target MCB11U10 RTX (ARM-ADS)
  device: LPC11U14/201 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10000FFF) IROM(0-0x7FFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: HID
  c flags: Optim=4
  c include: C:\Keil\ARM\INC\NXP\LPC11Uxx
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x1000
  group Startup Files
    ./: startup_LPC11Uxx.s system_LPC11Uxx.c SVC_Table.s
  group Configuration
    ./: usb_config.c RTX_Conf_CM.c
  group USB HW Driver
    ./: usbd_LPC11Uxx.c
  group Source
    ./: USBD_Demo.c usbd_user_hid.c
  group Library
    C:/Keil/ARM/RV31/LIB/: USB_CM1.lib
  group Documentation
    ./: Abstract.txt
