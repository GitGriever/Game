# Keil uVision project M2S050T_MSS_CM3_hw_platform.uvproj, settings and files
target Cortex-M3 (ARM-ADS)
  device: M2S050T Actel
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x00000000-0x0003FFFF) CLOCK(20000000) CPUTYPE("Cortex-M3")
  output: M2S050T_MSS_CM3_hw_platform (library)
  c flags: Optim=1
  c include: ./;./CMSIS;./CMSIS/startup_arm;./drivers;./drivers/mss_gpio;./drivers/mss_hpdma;./drivers/mss_nvm;./drivers/mss_pdma;./drivers/mss_sys_services;./drivers/mss_timer;./drivers/mss_uart;./drivers/mss_watchdog;./drivers_config;./drivers_config/sys_config;./hal;./hal/CortexM3;./hal/CortexM3/Keil
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Headers
    CMSIS/: hw_reg_io.h m2sxxx.h mss_assert.h sys_init_cfg_types.h system_m2sxxx.h
    ./: M2S050T_top_hw_platform.h
    drivers/mss_gpio/: mss_gpio.h
    drivers/mss_hpdma/: mss_hpdma.h
    drivers/mss_nvm/: mss_nvm.h
    drivers/mss_pdma/: mss_pdma.h
    drivers/mss_sys_services/: mss_comblk.h mss_sys_services.h
    drivers/mss_timer/: mss_timer.h
    drivers/mss_uart/: mss_uart.h mss_uart_regs.h
    drivers/mss_watchdog/: mss_watchdog.h
    drivers_config/sys_config/: sys_config.h sys_config_mss_clocks.h
    hal/CortexM3/Keil/: cpu_types.h hw_macros.h
    hal/CortexM3/: cortex_nvic.h cortex_nvic_regs.h
    hal/: hal.h hal_assert.h hw_reg_access.h
  group drivers
    drivers/mss_gpio/: mss_gpio.c
    drivers/mss_hpdma/: mss_hpdma.c
    drivers/mss_nvm/: mss_nvm.c
    drivers/mss_pdma/: mss_pdma.c
    drivers/mss_sys_services/: mss_comblk.c mss_sys_services.c
    drivers/mss_uart/: mss_uart.c
  group drivers_config
    drivers_config/sys_config/: sys_config.c
  group hal
    hal/CortexM3/Keil/: hal.s hal_assert.c hw_reg_access.s
    hal/CortexM3/: cortex_nvic.c
