# Keil uVision project MKE04Zxxx.uvproj, settings and files
target MKE04Zxxx_P8KB (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: MKE04Zxxx_P8KB
  AfterMake: cmd.exe /C copy ".\Out\%L" "..\@L.FLM"
  c flags: Optim=3
  c define: MKE04Zxxx_P8KB
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
  group Program Functions
    ./: FlashPrg.c
  group Device Description
    ./: FlashDev.c
target MKE04Zxxx_P64KB (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: MKE04Zxxx_P64KB
  AfterMake: cmd.exe /C copy ".\Out\%L" "..\@L.FLM"
  c flags: Optim=3
  c define: MKE04Zxxx_P64KB
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target MKE04Zxxx_P128KB (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: MKE04Zxxx_P128KB
  AfterMake: cmd.exe /C copy ".\Out\%L" "..\@L.FLM"
  c flags: Optim=3
  c define: MKE04Zxxx_P128KB
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
