# Keil uVision project VirtualCOM.uvproj, settings and files
target MCBSTM32F200 HS (ARM-ADS)
  device: STM32F207IG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: VirtualCOM
  c flags: Optim=4
  c define: __USART1
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Startup Files
    ./: startup_stm32f2xx.s system_stm32f2xx.c SVC_Table.s
  group Configuration
    ./: usb_config_FS.c usb_config_HS.c RTX_Conf_CM.c
  group USB HW Driver
    ./: usbd_STM32F2xx_FS.c usbd_STM32F2xx_HS.c
  group Source
    ./: USBD_Demo.c GLCD_16bitIF_STM32F2xx.c UART_STM32F2xx.c
    ./: usbd_user_cdc_acm.c
  group Library
    C:/Keil/ARM/RV31/LIB/: USB_CM3.lib
  group Documentation
    ./: Abstract.txt
target MCBSTM32F200 FS (ARM-ADS)
  device: STM32F207IG STMicroelectronics
  cpu: as above
  output: VirtualCOM
  c flags: Optim=4
  c define: __USART1
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
