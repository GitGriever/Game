# Keil uVision project Blinky.uvproj, settings and files
target Simulator (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Blinky
  c flags: Optim=1
  c define: STM32F10X_HD
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group System Files
    ./: startup_stm32f10x_hd.s system_stm32f10x.c
  group Source Files
    ./: Blinky.c Retarget.c IRQ.c Serial.c LED.c ADC.c
  group Trace Configuration
    ./: STM32_SWO.ini STM32_TP.ini
  group Documentation
    ./: Abstract.txt
target SWO Trace (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: as above
  output: Blinky
  c flags: Optim=1
  c define: STM32F10X_HD
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
target TracePort Trace (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: as above
  output: Blinky
  c flags: Optim=1
  c define: STM32F10X_HD
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
target TracePort InstructionTrace (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: as above
  output: Blinky
  c flags: Optim=1
  c define: STM32F10X_HD
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
