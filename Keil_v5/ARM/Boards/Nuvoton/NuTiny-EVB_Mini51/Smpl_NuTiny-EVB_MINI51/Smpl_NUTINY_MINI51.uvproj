# Keil uVision project Smpl_NUTINY_MINI51.uvproj, settings and files
target Smpl_NUTINY_MINI51 (ARM-ADS)
  device: MINI51LAN Nuvoton
  cpu: IRAM(0x20000000-0x200007FF) IROM(0-0x0FFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: Smpl_NUTINY_MINI51
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=1 OneElfS=1
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x1000
  memory RVCT9: RAM 0x20000000 size 0x800
  link misc: --map --first='startup_Mini51.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS files
    ./: startup_MINI51.s system_MINI51.c
  group Source files
    ./: Smpl_LED.c
  group Documentation
    ./: Abstract.txt
