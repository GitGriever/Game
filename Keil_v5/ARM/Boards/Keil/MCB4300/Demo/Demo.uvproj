# Keil uVision project Demo.uvproj, settings and files
target LPC4350 RAM (ARM-ADS)
  device: LPC4350 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x1001FFFF) IRAM2(0x20000000-0x2000FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") FPU2
  output: Demo
  c flags: Optim=1
  asm define: NO_CRP
  library: MicroLIB
  memory RVCT4: ROM 0x10000000 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x10000
  group Startup Code
    ./: startup_LPC43xx.s system_LPC43xx.c
  group Source
    ./: Demo.c LED_LPC43xx.c ADC_LPC43xx.c I2C_LPC43xx.c GLCD_LPC43xx.c Button_16bpp.c Arrows_16bpp_red.c Bulb_16bpp.c JOY_LPC43xx.c KBD_LPC43xx.c TSC_STMPE811.c TH_LM75.c EE_24LC128.c
  group Documentation
    ./: Abstract.txt
target LPC4350 Ext. Flash (ARM-ADS)
  device: LPC4350 NXP (founded by Philips)
  cpu: as above
  output: Demo
  c flags: Optim=4
  asm define: NO_CRP
  library: MicroLIB
  memory RVCT1: ROM 0x1c000000 size 0x1000000
  memory RVCT9: RAM 0x10000000 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x10000
target LPC4350 Ext. Flash Lite (ARM-ADS)
  device: LPC4350 NXP (founded by Philips)
  cpu: as above
  output: Demo
  c flags: Optim=4
  c define: _EVAL_VERSION_
  asm define: NO_CRP
  library: MicroLIB
  memory RVCT1: ROM 0x1c000000 size 0x1000000
  memory RVCT9: RAM 0x10000000 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x10000
target LPC4357 Flash (ARM-ADS)
  device: LPC4357 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x20000000-0x2000FFFF) IROM(0x1A000000-0x1A07FFFF) IROM2(0x1B000000-0x1B07FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") FPU2
  output: Demo
  AfterMake: $K\ARM\BIN\ElfDwT.exe !L BASEADDRESS(0x1A000000)
  c flags: Optim=4
  library: MicroLIB
  memory RVCT4: ROM 0x1a000000 size 0x80000
  memory RVCT5: ROM 0x1b000000 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x10000
target LPC4357 Flash Lite (ARM-ADS)
  device: LPC4357 NXP (founded by Philips)
  cpu: as above
  output: Demo
  AfterMake: $K\ARM\BIN\ElfDwT.exe !L BASEADDRESS(0x1A000000)
  c flags: Optim=4
  c define: _EVAL_VERSION_
  library: MicroLIB
  memory RVCT4: ROM 0x1a000000 size 0x80000
  memory RVCT5: ROM 0x1b000000 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x10000
