# Keil uVision project Blinky.uvproj, settings and files
target LM4F232 Flash (ARM-ADS)
  device: LM4F232H5QD Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: blinky
  c flags: Optim=1
  c define: rvmdk PART_LM4F232H5QD TARGET_IS_BLIZZARD_RA1
  c include: C:/Keil/ARM/RV31/LIB/Luminary
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group StartUp
    ./: startup_rvmdk_RTX.S
  group RTX Configuration
    ./: RTX_Conf_CM.c
  group Source Files
    ./: Blinky.c
  group Library
    C:/Keil/ARM/RV31/LIB/Luminary/: driverlib-cm4f.lib
  group Documentation
    ./: Abstract.txt
