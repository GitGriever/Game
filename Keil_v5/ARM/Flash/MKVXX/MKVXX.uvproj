# Keil uVision project MKVXX.uvproj, settings and files
target KV_P16_1KB_SEC (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: MKV_P16_1KB_SEC
  AfterMake: cmd.exe /C copy ".\Output\%L" "..\@L.FLM"
  c flags: Optim=3
  c define: MKV_P16_1KB_SEC
  c misc: --diag_suppress=1
  c include: .\C90TFS\drvsrc\include;..\..\INC\Freescale\Kinetis
  asm define: MKP128
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
  group Program Functions
    ./: FlashPrg.c
  group Device Description
    ./: FlashDev.c
  group Flash Library
    ./C90TFS/drvsrc/source/: DEFlashPartition.c DFlashGetProtection.c DFlashSetProtection.c EEEWrite.c EERAMGetProtection.c EERAMSetProtection.c FlashCheckSum.c FlashCommandSequence.c FlashEraseAllBlock.c FlashEraseBlock.c FlashEraseResume.c FlashEraseSector.c FlashEraseSuspend.c FlashGetInterruptEnable.c FlashGetSecurityState.c FlashInit.c FlashProgramCheck.c FlashProgramLongword.c FlashProgramOnce.c FlashProgramSection.c FlashReadOnce.c FlashReadResource.c FlashSecurityBypass.c FlashSetInterruptEnable.c FlashVerifyAllBlock.c FlashVerifyBlock.c FlashVerifySection.c PFlashGetProtection.c PFlashSetProtection.c SetEEEEnable.c FlashProgramPhrase.c FlashEraseSector_Keil.c FlashProgramLongword_Keil.c
target KV_P32_1KB_SEC (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: MKV_P32_1KB_SEC
  AfterMake: cmd.exe /C copy ".\Output\%L" "..\@L.FLM"
  c flags: Optim=3
  c define: MKV_P32_1KB_SEC
  c misc: --diag_suppress=1
  c include: .\C90TFS\drvsrc\include;..\..\INC\Freescale\Kinetis
  asm define: MKP128
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target MKV_PIFR_75MHZ (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: MKV_PIFR_75MHZ
  AfterMake: cmd.exe /C copy ".\Output\%L" "..\@L.FLM"
  c flags: Optim=3
  c define: MKV_PIFR_75MHZ
  c misc: --diag_suppress=1
  c include: .\C90TFS\drvsrc\include;..\..\INC\Freescale\Kinetis
  asm define: MKPIFR
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
