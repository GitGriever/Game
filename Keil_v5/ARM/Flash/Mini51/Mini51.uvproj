# Keil uVision project Mini51.uvproj, settings and files
target Mini51_4 APROM (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: Mini51_AP_4
  AfterMake: cmd.exe /C copy Mini51_AP_4.axf ..\Mini51_AP_4.FLM
  c flags: Optim=1
  c define: FLASH_APROM FLASH_4
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
  group Program Functions
    ./: FlashPrg.c
  group Device Description
    ./: FlashDev.c
target Mini51_8_APROM (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: Mini51_AP_8
  AfterMake: cmd.exe /C copy Mini51_AP_8.axf ..\Mini51_AP_8.FLM
  c flags: Optim=1
  c define: FLASH_APROM FLASH_8
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target Mini51_16_APROM (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: Mini51_AP_16
  AfterMake: cmd.exe /C copy Mini51_AP_16.axf ..\Mini51_AP_16.FLM
  c flags: Optim=1
  c define: FLASH_APROM FLASH_16
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target Mini51_2 LDROM (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: Mini51_LD_2
  AfterMake: cmd.exe /C copy Mini51_LD_2.axf ..\Mini51_LD_2.FLM
  c flags: Optim=1
  c define: FLASH_LDROM
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target Mini51 CFG (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: Mini51_CFG
  AfterMake: cmd.exe /C copy Mini51_CFG.axf ..\Mini51_CFG.FLM
  c flags: Optim=1
  c define: FLASH_CFG
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
