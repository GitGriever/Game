# Keil uVision project CC2538xxxx.uvproj, settings and files
target CC2538_128KB (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: CC2538_128KB
  AfterMake: cmd.exe /C copy ".\Out\%L" "..\@L.FLM"
  c flags: Optim=3
  c define: CC2538_128KB
  c include: .\Include
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
  group Program Functions
    ./: FlashPrg.c
  group Device Description
    ./: FlashDev.c
target CC2538_256KB (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: CC2538_256KB
  AfterMake: cmd.exe /C copy ".\Out\%L" "..\@L.FLM"
  c flags: Optim=3
  c define: CC2538_256KB
  c include: .\Include
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target CC2538_512KB (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: CC2538_512KB
  AfterMake: cmd.exe /C copy ".\Out\%L" "..\@L.FLM"
  c flags: Optim=3
  c define: CC2538_512KB
  c include: .\Include
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
